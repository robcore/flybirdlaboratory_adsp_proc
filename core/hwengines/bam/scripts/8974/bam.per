        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_1"
        group.long 0x2808--0x280B "BAM_P_PSM_CNTXT_2_1 (at 0xFC37E808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_1"
        group.long 0x280C--0x280F "BAM_P_PSM_CNTXT_3_1 (at 0xFC37E80C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_1"
        group.long 0x2810--0x2813 "BAM_P_PSM_CNTXT_4_1 (at 0xFC37E810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_1"
        group.long 0x2814--0x2817 "BAM_P_PSM_CNTXT_5_1 (at 0xFC37E814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 1
tree.end
tree.end
;Block Per Data Ends

base ad:0xF9304000
tree "USB30"
tree "BAM Control Registers"
      tree "BAM_CTRL"
        group.long 0x0--0x3 "BAM_CTRL (at 0xF9304000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x13 " [   19]   CACHE_MISS_ERR_RESP_EN                   = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11--0x12 " [18:17]   LOCAL_CLK_GATING                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   IBC_DISABLE                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0xF " [   15]   BAM_CACHED_DESC_STORE                    = "  "0,1"
        textline ""
        bitfld.long 0x0 0xD--0xE " [14:13]   BAM_DESC_CACHE_SEL                       = "  "0,1,2,3"
        textline ""
        hexmask.long.word 0x0 0x5--0xB 1  " [11:05]   BAM_TESTBUS_SEL                          = " 
        textline ""
        bitfld.long 0x0 0x4 " [   04]   BAM_EN_ACCUM                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_EN                                   = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   BAM_SW_RST                               = "  "0,1"
        textline ""
      tree.end
      tree "BAM_REVISION"
        group.long 0x4--0x7 "BAM_REVISION (at 0xF9304004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x18--0x1F 1  " [31:24]   INACTIV_TMR_BASE                         = " 
        textline ""
        bitfld.long 0x0 0x17 " [   23]   CMD_DESC_EN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15--0x16 " [22:21]   DESC_CACHE_DEPTH                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   NUM_INACTIV_TMRS                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x13 " [   19]   INACTIV_TMRS_EXST                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x12 " [   18]   HIGH_FREQUENCY_BAM                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11 " [   17]   BAM_HAS_NO_BYPASS                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   SECURED                                  = "  "0,1"
        textline ""
        bitfld.long 0x0 0xF " [   15]   USE_VMIDMT                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0xE " [   14]   AXI_ACTIVE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0xD " [   13]   CE_BUFFER_SIZE                           = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x8--0xB 1  " [11:08]   NUM_EES                                  = " 
        textline ""
        hexmask.long.word 0x0 0x0--0x7 1  " [07:00]   REVISION                                 = " 
        textline ""
      tree.end
      tree "BAM_SW_VERSION"
        group.long 0x80--0x83 "BAM_SW_VERSION (at 0xF9304080) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x1C--0x1F 1  " [31:28]   MAJOR                                    = " 
        textline ""
        hexmask.long.word 0x0 0x10--0x1B 1  " [27:16]   MINOR                                    = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   STEP                                     = " 
        textline ""
      tree.end
      tree "BAM_NUM_PIPES"
        group.long 0x3C--0x3F "BAM_NUM_PIPES (at 0xF930403C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x18--0x1F 1  " [31:24]   BAM_NON_PIPE_GRP                         = " 
        textline ""
        hexmask.long.word 0x0 0x10--0x17 1  " [23:16]   PERIPH_NON_PIPE_GRP                      = " 
        textline ""
        hexmask.long.word 0x0 0x0--0x7 1  " [07:00]   BAM_NUM_PIPES                            = " 
        textline ""
      tree.end
      tree "BAM_TIMER"
        group.long 0x40--0x43 "BAM_TIMER (at 0xF9304040) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   TIMER                                    = " 
        textline ""
      tree.end
      tree "BAM_TIMER_CTRL"
        group.long 0x44--0x47 "BAM_TIMER_CTRL (at 0xF9304044) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   TIMER_RST                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   TIMER_RUN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   TIMER_MODE                               = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   TIMER_TRSHLD                             = " 
        textline ""
      tree.end
      tree "BAM_DESC_CNT_TRSHLD"
        group.long 0x8--0xB "BAM_DESC_CNT_TRSHLD (at 0xF9304008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   CNT_TRSHLD                               = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS"
        group.long 0xC--0xF "BAM_IRQ_SRCS (at 0xF930400C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK"
        group.long 0x10--0x13 "BAM_IRQ_SRCS_MSK (at 0xF9304010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED"
        group.long 0x30--0x33 "BAM_IRQ_SRCS_UNMASKED (at 0xF9304030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_STTS"
        group.long 0x14--0x17 "BAM_IRQ_STTS (at 0xF9304014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x4 " [   04]   BAM_TIMER_IRQ                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   BAM_EMPTY_IRQ                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_ERROR_IRQ                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_HRESP_ERR_IRQ                        = "  "0,1"
        textline ""
      tree.end
      tree "BAM_IRQ_CLR"
        group.long 0x18--0x1B "BAM_IRQ_CLR (at 0xF9304018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x4 " [   04]   BAM_TIMER_CLR                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   BAM_EMPTY_CLR                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_ERROR_CLR                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_HRESP_ERR_CLR                        = "  "0,1"
        textline ""
      tree.end
      tree "BAM_IRQ_EN"
        group.long 0x1C--0x1F "BAM_IRQ_EN (at 0xF930401C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x4 " [   04]   BAM_TIMER_EN                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   BAM_EMPTY_EN                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_ERROR_EN                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_HRESP_ERR_EN                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_AHB_MASTER_ERR_CTRLS"
        group.long 0x24--0x27 "BAM_AHB_MASTER_ERR_CTRLS (at 0xF9304024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x12--0x16 1  " [22:18]   BAM_ERR_HVMID                            = " 
        textline ""
        bitfld.long 0x0 0x11 " [   17]   BAM_ERR_DIRECT_MODE                      = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0xC--0x10 1  " [16:12]   BAM_ERR_HCID                             = " 
        textline ""
        hexmask.long.word 0x0 0x8--0xB 1  " [11:08]   BAM_ERR_HPROT                            = " 
        textline ""
        bitfld.long 0x0 0x5--0x7 " [07:05]   BAM_ERR_HBURST                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x3--0x4 " [04:03]   BAM_ERR_HSIZE                            = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_ERR_HWRITE                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0--0x1 " [01:00]   BAM_ERR_HTRANS                           = "  "0,1,2,3"
        textline ""
      tree.end
      tree "BAM_AHB_MASTER_ERR_ADDR"
        group.long 0x28--0x2B "BAM_AHB_MASTER_ERR_ADDR (at 0xF9304028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   BAM_ERR_ADDR                             = " 
        textline ""
      tree.end
      tree "BAM_AHB_MASTER_ERR_DATA"
        group.long 0x2C--0x2F "BAM_AHB_MASTER_ERR_DATA (at 0xF930402C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   BAM_ERR_DATA                             = " 
        textline ""
      tree.end
      tree "BAM_TRUST_REG"
        group.long 0x70--0x73 "BAM_TRUST_REG (at 0xF9304070) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0xD " [   13]   LOCK_EE_CTRL                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_VMID                                 = " 
        textline ""
        bitfld.long 0x0 0x7 " [   07]   BAM_RST_BLOCK                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_EE                                   = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_TEST_BUS_SEL"
        group.long 0x74--0x77 "BAM_TEST_BUS_SEL (at 0xF9304074) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x15 " [   21]   SW_EVENTS_ZERO                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x13--0x14 " [20:19]   SW_EVENTS_SEL                            = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x12 " [   18]   BAM_DATA_ERASE                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11 " [   17]   BAM_DATA_FLUSH                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   BAM_CLK_ALWAYS_ON                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x0--0x6 1  " [06:00]   BAM_TESTBUS_SEL                          = " 
        textline ""
      tree.end
      tree "BAM_TEST_BUS_REG"
        group.long 0x78--0x7B "BAM_TEST_BUS_REG (at 0xF9304078) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   BAM_TESTBUS_REG                          = " 
        textline ""
      tree.end
      tree "BAM_CNFG_BITS"
        group.long 0x7C--0x7F "BAM_CNFG_BITS (at 0xF930407C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1E " [   30]   MULTIPLE_EVENTS_DESC_AVAIL_EN            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   MULTIPLE_EVENTS_SIZE_EN                  = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1C " [   28]   BAM_ZLT_W_CD_SUPPORT                     = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1B " [   27]   BAM_CD_ENABLE                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1A " [   26]   BAM_AU_ACCUMED                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x19 " [   25]   BAM_PSM_P_HD_DATA                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_REG_P_EN                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_WB_DSC_AVL_P_RST                     = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_WB_RETR_SVPNT                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_WB_CSW_ACK_IDL                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_WB_BLK_CSW                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x13 " [   19]   BAM_WB_P_RES                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x12 " [   18]   BAM_SI_P_RES                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11 " [   17]   BAM_AU_P_RES                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   BAM_PSM_P_RES                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0xF " [   15]   BAM_PSM_CSW_REQ                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0xE " [   14]   BAM_SB_CLK_REQ                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0xD " [   13]   BAM_IBC_DISABLE                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0xC " [   12]   BAM_NO_EXT_P_RST                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0xB " [   11]   BAM_FULL_PIPE                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   BAM_ADML_SYNC_BRIDGE                     = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_PIPE_CNFG                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_ADML_DEEP_CONS_FIFO                  = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   BAM_ADML_INCR4_EN_N                      = "  "0,1"
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE0"
        group.long 0x800--0x803 "BAM_IRQ_SRCS_EE0 (at 0xF9304800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE1"
        group.long 0x880--0x883 "BAM_IRQ_SRCS_EE1 (at 0xF9304880) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE2"
        group.long 0x900--0x903 "BAM_IRQ_SRCS_EE2 (at 0xF9304900) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE3"
        group.long 0x980--0x983 "BAM_IRQ_SRCS_EE3 (at 0xF9304980) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE4"
        group.long 0xA00--0xA03 "BAM_IRQ_SRCS_EE4 (at 0xF9304A00) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE5"
        group.long 0xA80--0xA83 "BAM_IRQ_SRCS_EE5 (at 0xF9304A80) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE6"
        group.long 0xB00--0xB03 "BAM_IRQ_SRCS_EE6 (at 0xF9304B00) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE7"
        group.long 0xB80--0xB83 "BAM_IRQ_SRCS_EE7 (at 0xF9304B80) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE0"
        group.long 0x804--0x807 "BAM_IRQ_SRCS_MSK_EE0 (at 0xF9304804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE1"
        group.long 0x884--0x887 "BAM_IRQ_SRCS_MSK_EE1 (at 0xF9304884) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE2"
        group.long 0x904--0x907 "BAM_IRQ_SRCS_MSK_EE2 (at 0xF9304904) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE3"
        group.long 0x984--0x987 "BAM_IRQ_SRCS_MSK_EE3 (at 0xF9304984) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE4"
        group.long 0xA04--0xA07 "BAM_IRQ_SRCS_MSK_EE4 (at 0xF9304A04) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE5"
        group.long 0xA84--0xA87 "BAM_IRQ_SRCS_MSK_EE5 (at 0xF9304A84) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE6"
        group.long 0xB04--0xB07 "BAM_IRQ_SRCS_MSK_EE6 (at 0xF9304B04) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE7"
        group.long 0xB84--0xB87 "BAM_IRQ_SRCS_MSK_EE7 (at 0xF9304B84) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE0"
        group.long 0x808--0x80B "BAM_IRQ_SRCS_UNMASKED_EE0 (at 0xF9304808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE1"
        group.long 0x888--0x88B "BAM_IRQ_SRCS_UNMASKED_EE1 (at 0xF9304888) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE2"
        group.long 0x908--0x90B "BAM_IRQ_SRCS_UNMASKED_EE2 (at 0xF9304908) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE3"
        group.long 0x988--0x98B "BAM_IRQ_SRCS_UNMASKED_EE3 (at 0xF9304988) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE4"
        group.long 0xA08--0xA0B "BAM_IRQ_SRCS_UNMASKED_EE4 (at 0xF9304A08) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE5"
        group.long 0xA88--0xA8B "BAM_IRQ_SRCS_UNMASKED_EE5 (at 0xF9304A88) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE6"
        group.long 0xB08--0xB0B "BAM_IRQ_SRCS_UNMASKED_EE6 (at 0xF9304B08) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE7"
        group.long 0xB88--0xB8B "BAM_IRQ_SRCS_UNMASKED_EE7 (at 0xF9304B88) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
;End of BAM Control Registers
tree.end
tree "Pipe 0"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL0"
        group.long 0x1000--0x1003 "BAM_P_CTRL0 (at 0xF9305000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST0"
        group.long 0x1004--0x1007 "BAM_P_RST0 (at 0xF9305004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT0"
        group.long 0x1008--0x100B "BAM_P_HALT0 (at 0xF9305008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG0"
        group.long 0x1030--0x1033 "BAM_P_TRUST_REG0 (at 0xF9305030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS0"
        group.long 0x1010--0x1013 "BAM_P_IRQ_STTS0 (at 0xF9305010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR0"
        group.long 0x1014--0x1017 "BAM_P_IRQ_CLR0 (at 0xF9305014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN0"
        group.long 0x1018--0x101B "BAM_P_IRQ_EN0 (at 0xF9305018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER0"
        group.long 0x101C--0x101F "BAM_P_TIMER0 (at 0xF930501C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL0"
        group.long 0x1020--0x1023 "BAM_P_TIMER_CTRL0 (at 0xF9305020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND0"
        group.long 0x1024--0x1027 "BAM_P_PRDCR_SDBND0 (at 0xF9305024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND0"
        group.long 0x1028--0x102B "BAM_P_CNSMR_SDBND0 (at 0xF9305028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR0"
        group.long 0x182C--0x182F "BAM_P_EVNT_DEST_ADDR0 (at 0xF930582C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG0"
        group.long 0x1818--0x181B "BAM_P_EVNT_REG0 (at 0xF9305818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS0"
        group.long 0x1800--0x1803 "BAM_P_SW_OFSTS0 (at 0xF9305800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR0"
        group.long 0x1824--0x1827 "BAM_P_DATA_FIFO_ADDR0 (at 0xF9305824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR0"
        group.long 0x181C--0x181F "BAM_P_DESC_FIFO_ADDR0 (at 0xF930581C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD0"
        group.long 0x1828--0x182B "BAM_P_EVNT_GEN_TRSHLD0 (at 0xF9305828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES0"
        group.long 0x1820--0x1823 "BAM_P_FIFO_SIZES0 (at 0xF9305820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_0"
        group.long 0x1834--0x1837 "BAM_P_RETR_CNTXT_0 (at 0xF9305834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_0"
        group.long 0x1838--0x183B "BAM_P_SI_CNTXT_0 (at 0xF9305838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_0"
        group.long 0x1830--0x1833 "BAM_P_DF_CNTXT_0 (at 0xF9305830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_0"
        group.long 0x1804--0x1807 "BAM_P_AU_PSM_CNTXT_1_0 (at 0xF9305804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_0"
        group.long 0x1808--0x180B "BAM_P_PSM_CNTXT_2_0 (at 0xF9305808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_0"
        group.long 0x180C--0x180F "BAM_P_PSM_CNTXT_3_0 (at 0xF930580C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_0"
        group.long 0x1810--0x1813 "BAM_P_PSM_CNTXT_4_0 (at 0xF9305810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_0"
        group.long 0x1814--0x1817 "BAM_P_PSM_CNTXT_5_0 (at 0xF9305814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 0
tree.end
tree "Pipe 1"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL1"
        group.long 0x2000--0x2003 "BAM_P_CTRL1 (at 0xF9306000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST1"
        group.long 0x2004--0x2007 "BAM_P_RST1 (at 0xF9306004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT1"
        group.long 0x2008--0x200B "BAM_P_HALT1 (at 0xF9306008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG1"
        group.long 0x2030--0x2033 "BAM_P_TRUST_REG1 (at 0xF9306030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS1"
        group.long 0x2010--0x2013 "BAM_P_IRQ_STTS1 (at 0xF9306010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR1"
        group.long 0x2014--0x2017 "BAM_P_IRQ_CLR1 (at 0xF9306014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN1"
        group.long 0x2018--0x201B "BAM_P_IRQ_EN1 (at 0xF9306018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER1"
        group.long 0x201C--0x201F "BAM_P_TIMER1 (at 0xF930601C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL1"
        group.long 0x2020--0x2023 "BAM_P_TIMER_CTRL1 (at 0xF9306020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND1"
        group.long 0x2024--0x2027 "BAM_P_PRDCR_SDBND1 (at 0xF9306024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND1"
        group.long 0x2028--0x202B "BAM_P_CNSMR_SDBND1 (at 0xF9306028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR1"
        group.long 0x282C--0x282F "BAM_P_EVNT_DEST_ADDR1 (at 0xF930682C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG1"
        group.long 0x2818--0x281B "BAM_P_EVNT_REG1 (at 0xF9306818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS1"
        group.long 0x2800--0x2803 "BAM_P_SW_OFSTS1 (at 0xF9306800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR1"
        group.long 0x2824--0x2827 "BAM_P_DATA_FIFO_ADDR1 (at 0xF9306824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR1"
        group.long 0x281C--0x281F "BAM_P_DESC_FIFO_ADDR1 (at 0xF930681C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD1"
        group.long 0x2828--0x282B "BAM_P_EVNT_GEN_TRSHLD1 (at 0xF9306828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES1"
        group.long 0x2820--0x2823 "BAM_P_FIFO_SIZES1 (at 0xF9306820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_1"
        group.long 0x2834--0x2837 "BAM_P_RETR_CNTXT_1 (at 0xF9306834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_1"
        group.long 0x2838--0x283B "BAM_P_SI_CNTXT_1 (at 0xF9306838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_1"
        group.long 0x2830--0x2833 "BAM_P_DF_CNTXT_1 (at 0xF9306830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_1"
        group.long 0x2804--0x2807 "BAM_P_AU_PSM_CNTXT_1_1 (at 0xF9306804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_1"
        group.long 0x2808--0x280B "BAM_P_PSM_CNTXT_2_1 (at 0xF9306808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_1"
        group.long 0x280C--0x280F "BAM_P_PSM_CNTXT_3_1 (at 0xF930680C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_1"
        group.long 0x2810--0x2813 "BAM_P_PSM_CNTXT_4_1 (at 0xF9306810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_1"
        group.long 0x2814--0x2817 "BAM_P_PSM_CNTXT_5_1 (at 0xF9306814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 1
tree.end
tree "Pipe 2"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL2"
        group.long 0x3000--0x3003 "BAM_P_CTRL2 (at 0xF9307000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST2"
        group.long 0x3004--0x3007 "BAM_P_RST2 (at 0xF9307004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT2"
        group.long 0x3008--0x300B "BAM_P_HALT2 (at 0xF9307008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG2"
        group.long 0x3030--0x3033 "BAM_P_TRUST_REG2 (at 0xF9307030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS2"
        group.long 0x3010--0x3013 "BAM_P_IRQ_STTS2 (at 0xF9307010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR2"
        group.long 0x3014--0x3017 "BAM_P_IRQ_CLR2 (at 0xF9307014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN2"
        group.long 0x3018--0x301B "BAM_P_IRQ_EN2 (at 0xF9307018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER2"
        group.long 0x301C--0x301F "BAM_P_TIMER2 (at 0xF930701C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL2"
        group.long 0x3020--0x3023 "BAM_P_TIMER_CTRL2 (at 0xF9307020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND2"
        group.long 0x3024--0x3027 "BAM_P_PRDCR_SDBND2 (at 0xF9307024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND2"
        group.long 0x3028--0x302B "BAM_P_CNSMR_SDBND2 (at 0xF9307028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR2"
        group.long 0x382C--0x382F "BAM_P_EVNT_DEST_ADDR2 (at 0xF930782C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG2"
        group.long 0x3818--0x381B "BAM_P_EVNT_REG2 (at 0xF9307818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS2"
        group.long 0x3800--0x3803 "BAM_P_SW_OFSTS2 (at 0xF9307800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR2"
        group.long 0x3824--0x3827 "BAM_P_DATA_FIFO_ADDR2 (at 0xF9307824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR2"
        group.long 0x381C--0x381F "BAM_P_DESC_FIFO_ADDR2 (at 0xF930781C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD2"
        group.long 0x3828--0x382B "BAM_P_EVNT_GEN_TRSHLD2 (at 0xF9307828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES2"
        group.long 0x3820--0x3823 "BAM_P_FIFO_SIZES2 (at 0xF9307820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_2"
        group.long 0x3834--0x3837 "BAM_P_RETR_CNTXT_2 (at 0xF9307834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_2"
        group.long 0x3838--0x383B "BAM_P_SI_CNTXT_2 (at 0xF9307838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_2"
        group.long 0x3830--0x3833 "BAM_P_DF_CNTXT_2 (at 0xF9307830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_2"
        group.long 0x3804--0x3807 "BAM_P_AU_PSM_CNTXT_1_2 (at 0xF9307804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_2"
        group.long 0x3808--0x380B "BAM_P_PSM_CNTXT_2_2 (at 0xF9307808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_2"
        group.long 0x380C--0x380F "BAM_P_PSM_CNTXT_3_2 (at 0xF930780C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_2"
        group.long 0x3810--0x3813 "BAM_P_PSM_CNTXT_4_2 (at 0xF9307810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_2"
        group.long 0x3814--0x3817 "BAM_P_PSM_CNTXT_5_2 (at 0xF9307814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 2
tree.end
tree "Pipe 3"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL3"
        group.long 0x4000--0x4003 "BAM_P_CTRL3 (at 0xF9308000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST3"
        group.long 0x4004--0x4007 "BAM_P_RST3 (at 0xF9308004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT3"
        group.long 0x4008--0x400B "BAM_P_HALT3 (at 0xF9308008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG3"
        group.long 0x4030--0x4033 "BAM_P_TRUST_REG3 (at 0xF9308030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS3"
        group.long 0x4010--0x4013 "BAM_P_IRQ_STTS3 (at 0xF9308010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR3"
        group.long 0x4014--0x4017 "BAM_P_IRQ_CLR3 (at 0xF9308014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN3"
        group.long 0x4018--0x401B "BAM_P_IRQ_EN3 (at 0xF9308018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER3"
        group.long 0x401C--0x401F "BAM_P_TIMER3 (at 0xF930801C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL3"
        group.long 0x4020--0x4023 "BAM_P_TIMER_CTRL3 (at 0xF9308020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND3"
        group.long 0x4024--0x4027 "BAM_P_PRDCR_SDBND3 (at 0xF9308024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND3"
        group.long 0x4028--0x402B "BAM_P_CNSMR_SDBND3 (at 0xF9308028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR3"
        group.long 0x482C--0x482F "BAM_P_EVNT_DEST_ADDR3 (at 0xF930882C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG3"
        group.long 0x4818--0x481B "BAM_P_EVNT_REG3 (at 0xF9308818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS3"
        group.long 0x4800--0x4803 "BAM_P_SW_OFSTS3 (at 0xF9308800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR3"
        group.long 0x4824--0x4827 "BAM_P_DATA_FIFO_ADDR3 (at 0xF9308824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR3"
        group.long 0x481C--0x481F "BAM_P_DESC_FIFO_ADDR3 (at 0xF930881C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD3"
        group.long 0x4828--0x482B "BAM_P_EVNT_GEN_TRSHLD3 (at 0xF9308828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES3"
        group.long 0x4820--0x4823 "BAM_P_FIFO_SIZES3 (at 0xF9308820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_3"
        group.long 0x4834--0x4837 "BAM_P_RETR_CNTXT_3 (at 0xF9308834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_3"
        group.long 0x4838--0x483B "BAM_P_SI_CNTXT_3 (at 0xF9308838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_3"
        group.long 0x4830--0x4833 "BAM_P_DF_CNTXT_3 (at 0xF9308830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_3"
        group.long 0x4804--0x4807 "BAM_P_AU_PSM_CNTXT_1_3 (at 0xF9308804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_3"
        group.long 0x4808--0x480B "BAM_P_PSM_CNTXT_2_3 (at 0xF9308808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_3"
        group.long 0x480C--0x480F "BAM_P_PSM_CNTXT_3_3 (at 0xF930880C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_3"
        group.long 0x4810--0x4813 "BAM_P_PSM_CNTXT_4_3 (at 0xF9308810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_3"
        group.long 0x4814--0x4817 "BAM_P_PSM_CNTXT_5_3 (at 0xF9308814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 3
tree.end
tree.end
;Block Per Data Ends

