      tree "BAM_P_IRQ_EN16"
        group.long 0x11018--0x1101B "BAM_P_IRQ_EN16 (at 0xF9955018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER16"
        group.long 0x1101C--0x1101F "BAM_P_TIMER16 (at 0xF995501C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL16"
        group.long 0x11020--0x11023 "BAM_P_TIMER_CTRL16 (at 0xF9955020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND16"
        group.long 0x11024--0x11027 "BAM_P_PRDCR_SDBND16 (at 0xF9955024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND16"
        group.long 0x11028--0x1102B "BAM_P_CNSMR_SDBND16 (at 0xF9955028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR16"
        group.long 0x1182C--0x1182F "BAM_P_EVNT_DEST_ADDR16 (at 0xF995582C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG16"
        group.long 0x11818--0x1181B "BAM_P_EVNT_REG16 (at 0xF9955818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS16"
        group.long 0x11800--0x11803 "BAM_P_SW_OFSTS16 (at 0xF9955800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR16"
        group.long 0x11824--0x11827 "BAM_P_DATA_FIFO_ADDR16 (at 0xF9955824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR16"
        group.long 0x1181C--0x1181F "BAM_P_DESC_FIFO_ADDR16 (at 0xF995581C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD16"
        group.long 0x11828--0x1182B "BAM_P_EVNT_GEN_TRSHLD16 (at 0xF9955828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES16"
        group.long 0x11820--0x11823 "BAM_P_FIFO_SIZES16 (at 0xF9955820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_16"
        group.long 0x11834--0x11837 "BAM_P_RETR_CNTXT_16 (at 0xF9955834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_16"
        group.long 0x11838--0x1183B "BAM_P_SI_CNTXT_16 (at 0xF9955838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_16"
        group.long 0x11830--0x11833 "BAM_P_DF_CNTXT_16 (at 0xF9955830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_16"
        group.long 0x11804--0x11807 "BAM_P_AU_PSM_CNTXT_1_16 (at 0xF9955804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_16"
        group.long 0x11808--0x1180B "BAM_P_PSM_CNTXT_2_16 (at 0xF9955808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_16"
        group.long 0x1180C--0x1180F "BAM_P_PSM_CNTXT_3_16 (at 0xF995580C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_16"
        group.long 0x11810--0x11813 "BAM_P_PSM_CNTXT_4_16 (at 0xF9955810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_16"
        group.long 0x11814--0x11817 "BAM_P_PSM_CNTXT_5_16 (at 0xF9955814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 16
tree.end
tree "Pipe 17"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL17"
        group.long 0x12000--0x12003 "BAM_P_CTRL17 (at 0xF9956000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST17"
        group.long 0x12004--0x12007 "BAM_P_RST17 (at 0xF9956004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT17"
        group.long 0x12008--0x1200B "BAM_P_HALT17 (at 0xF9956008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG17"
        group.long 0x12030--0x12033 "BAM_P_TRUST_REG17 (at 0xF9956030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS17"
        group.long 0x12010--0x12013 "BAM_P_IRQ_STTS17 (at 0xF9956010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR17"
        group.long 0x12014--0x12017 "BAM_P_IRQ_CLR17 (at 0xF9956014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN17"
        group.long 0x12018--0x1201B "BAM_P_IRQ_EN17 (at 0xF9956018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER17"
        group.long 0x1201C--0x1201F "BAM_P_TIMER17 (at 0xF995601C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL17"
        group.long 0x12020--0x12023 "BAM_P_TIMER_CTRL17 (at 0xF9956020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND17"
        group.long 0x12024--0x12027 "BAM_P_PRDCR_SDBND17 (at 0xF9956024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND17"
        group.long 0x12028--0x1202B "BAM_P_CNSMR_SDBND17 (at 0xF9956028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR17"
        group.long 0x1282C--0x1282F "BAM_P_EVNT_DEST_ADDR17 (at 0xF995682C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG17"
        group.long 0x12818--0x1281B "BAM_P_EVNT_REG17 (at 0xF9956818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS17"
        group.long 0x12800--0x12803 "BAM_P_SW_OFSTS17 (at 0xF9956800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR17"
        group.long 0x12824--0x12827 "BAM_P_DATA_FIFO_ADDR17 (at 0xF9956824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR17"
        group.long 0x1281C--0x1281F "BAM_P_DESC_FIFO_ADDR17 (at 0xF995681C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD17"
        group.long 0x12828--0x1282B "BAM_P_EVNT_GEN_TRSHLD17 (at 0xF9956828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES17"
        group.long 0x12820--0x12823 "BAM_P_FIFO_SIZES17 (at 0xF9956820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_17"
        group.long 0x12834--0x12837 "BAM_P_RETR_CNTXT_17 (at 0xF9956834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_17"
        group.long 0x12838--0x1283B "BAM_P_SI_CNTXT_17 (at 0xF9956838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_17"
        group.long 0x12830--0x12833 "BAM_P_DF_CNTXT_17 (at 0xF9956830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_17"
        group.long 0x12804--0x12807 "BAM_P_AU_PSM_CNTXT_1_17 (at 0xF9956804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_17"
        group.long 0x12808--0x1280B "BAM_P_PSM_CNTXT_2_17 (at 0xF9956808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_17"
        group.long 0x1280C--0x1280F "BAM_P_PSM_CNTXT_3_17 (at 0xF995680C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_17"
        group.long 0x12810--0x12813 "BAM_P_PSM_CNTXT_4_17 (at 0xF9956810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_17"
        group.long 0x12814--0x12817 "BAM_P_PSM_CNTXT_5_17 (at 0xF9956814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 17
tree.end
tree "Pipe 18"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL18"
        group.long 0x13000--0x13003 "BAM_P_CTRL18 (at 0xF9957000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST18"
        group.long 0x13004--0x13007 "BAM_P_RST18 (at 0xF9957004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT18"
        group.long 0x13008--0x1300B "BAM_P_HALT18 (at 0xF9957008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG18"
        group.long 0x13030--0x13033 "BAM_P_TRUST_REG18 (at 0xF9957030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS18"
        group.long 0x13010--0x13013 "BAM_P_IRQ_STTS18 (at 0xF9957010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR18"
        group.long 0x13014--0x13017 "BAM_P_IRQ_CLR18 (at 0xF9957014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN18"
        group.long 0x13018--0x1301B "BAM_P_IRQ_EN18 (at 0xF9957018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER18"
        group.long 0x1301C--0x1301F "BAM_P_TIMER18 (at 0xF995701C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL18"
        group.long 0x13020--0x13023 "BAM_P_TIMER_CTRL18 (at 0xF9957020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND18"
        group.long 0x13024--0x13027 "BAM_P_PRDCR_SDBND18 (at 0xF9957024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND18"
        group.long 0x13028--0x1302B "BAM_P_CNSMR_SDBND18 (at 0xF9957028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR18"
        group.long 0x1382C--0x1382F "BAM_P_EVNT_DEST_ADDR18 (at 0xF995782C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG18"
        group.long 0x13818--0x1381B "BAM_P_EVNT_REG18 (at 0xF9957818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS18"
        group.long 0x13800--0x13803 "BAM_P_SW_OFSTS18 (at 0xF9957800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR18"
        group.long 0x13824--0x13827 "BAM_P_DATA_FIFO_ADDR18 (at 0xF9957824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR18"
        group.long 0x1381C--0x1381F "BAM_P_DESC_FIFO_ADDR18 (at 0xF995781C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD18"
        group.long 0x13828--0x1382B "BAM_P_EVNT_GEN_TRSHLD18 (at 0xF9957828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES18"
        group.long 0x13820--0x13823 "BAM_P_FIFO_SIZES18 (at 0xF9957820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_18"
        group.long 0x13834--0x13837 "BAM_P_RETR_CNTXT_18 (at 0xF9957834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_18"
        group.long 0x13838--0x1383B "BAM_P_SI_CNTXT_18 (at 0xF9957838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_18"
        group.long 0x13830--0x13833 "BAM_P_DF_CNTXT_18 (at 0xF9957830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_18"
        group.long 0x13804--0x13807 "BAM_P_AU_PSM_CNTXT_1_18 (at 0xF9957804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_18"
        group.long 0x13808--0x1380B "BAM_P_PSM_CNTXT_2_18 (at 0xF9957808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_18"
        group.long 0x1380C--0x1380F "BAM_P_PSM_CNTXT_3_18 (at 0xF995780C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_18"
        group.long 0x13810--0x13813 "BAM_P_PSM_CNTXT_4_18 (at 0xF9957810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_18"
        group.long 0x13814--0x13817 "BAM_P_PSM_CNTXT_5_18 (at 0xF9957814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 18
tree.end
tree "Pipe 19"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL19"
        group.long 0x14000--0x14003 "BAM_P_CTRL19 (at 0xF9958000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST19"
        group.long 0x14004--0x14007 "BAM_P_RST19 (at 0xF9958004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT19"
        group.long 0x14008--0x1400B "BAM_P_HALT19 (at 0xF9958008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG19"
        group.long 0x14030--0x14033 "BAM_P_TRUST_REG19 (at 0xF9958030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS19"
        group.long 0x14010--0x14013 "BAM_P_IRQ_STTS19 (at 0xF9958010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR19"
        group.long 0x14014--0x14017 "BAM_P_IRQ_CLR19 (at 0xF9958014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN19"
        group.long 0x14018--0x1401B "BAM_P_IRQ_EN19 (at 0xF9958018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER19"
        group.long 0x1401C--0x1401F "BAM_P_TIMER19 (at 0xF995801C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL19"
        group.long 0x14020--0x14023 "BAM_P_TIMER_CTRL19 (at 0xF9958020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND19"
        group.long 0x14024--0x14027 "BAM_P_PRDCR_SDBND19 (at 0xF9958024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND19"
        group.long 0x14028--0x1402B "BAM_P_CNSMR_SDBND19 (at 0xF9958028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR19"
        group.long 0x1482C--0x1482F "BAM_P_EVNT_DEST_ADDR19 (at 0xF995882C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG19"
        group.long 0x14818--0x1481B "BAM_P_EVNT_REG19 (at 0xF9958818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS19"
        group.long 0x14800--0x14803 "BAM_P_SW_OFSTS19 (at 0xF9958800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR19"
        group.long 0x14824--0x14827 "BAM_P_DATA_FIFO_ADDR19 (at 0xF9958824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR19"
        group.long 0x1481C--0x1481F "BAM_P_DESC_FIFO_ADDR19 (at 0xF995881C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD19"
        group.long 0x14828--0x1482B "BAM_P_EVNT_GEN_TRSHLD19 (at 0xF9958828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES19"
        group.long 0x14820--0x14823 "BAM_P_FIFO_SIZES19 (at 0xF9958820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_19"
        group.long 0x14834--0x14837 "BAM_P_RETR_CNTXT_19 (at 0xF9958834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_19"
        group.long 0x14838--0x1483B "BAM_P_SI_CNTXT_19 (at 0xF9958838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_19"
        group.long 0x14830--0x14833 "BAM_P_DF_CNTXT_19 (at 0xF9958830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_19"
        group.long 0x14804--0x14807 "BAM_P_AU_PSM_CNTXT_1_19 (at 0xF9958804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_19"
        group.long 0x14808--0x1480B "BAM_P_PSM_CNTXT_2_19 (at 0xF9958808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_19"
        group.long 0x1480C--0x1480F "BAM_P_PSM_CNTXT_3_19 (at 0xF995880C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_19"
        group.long 0x14810--0x14813 "BAM_P_PSM_CNTXT_4_19 (at 0xF9958810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_19"
        group.long 0x14814--0x14817 "BAM_P_PSM_CNTXT_5_19 (at 0xF9958814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 19
tree.end
tree "Pipe 20"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL20"
        group.long 0x15000--0x15003 "BAM_P_CTRL20 (at 0xF9959000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST20"
        group.long 0x15004--0x15007 "BAM_P_RST20 (at 0xF9959004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT20"
        group.long 0x15008--0x1500B "BAM_P_HALT20 (at 0xF9959008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG20"
        group.long 0x15030--0x15033 "BAM_P_TRUST_REG20 (at 0xF9959030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS20"
        group.long 0x15010--0x15013 "BAM_P_IRQ_STTS20 (at 0xF9959010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR20"
        group.long 0x15014--0x15017 "BAM_P_IRQ_CLR20 (at 0xF9959014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN20"
        group.long 0x15018--0x1501B "BAM_P_IRQ_EN20 (at 0xF9959018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER20"
        group.long 0x1501C--0x1501F "BAM_P_TIMER20 (at 0xF995901C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL20"
        group.long 0x15020--0x15023 "BAM_P_TIMER_CTRL20 (at 0xF9959020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND20"
        group.long 0x15024--0x15027 "BAM_P_PRDCR_SDBND20 (at 0xF9959024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND20"
        group.long 0x15028--0x1502B "BAM_P_CNSMR_SDBND20 (at 0xF9959028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR20"
        group.long 0x1582C--0x1582F "BAM_P_EVNT_DEST_ADDR20 (at 0xF995982C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG20"
        group.long 0x15818--0x1581B "BAM_P_EVNT_REG20 (at 0xF9959818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS20"
        group.long 0x15800--0x15803 "BAM_P_SW_OFSTS20 (at 0xF9959800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR20"
        group.long 0x15824--0x15827 "BAM_P_DATA_FIFO_ADDR20 (at 0xF9959824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR20"
        group.long 0x1581C--0x1581F "BAM_P_DESC_FIFO_ADDR20 (at 0xF995981C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD20"
        group.long 0x15828--0x1582B "BAM_P_EVNT_GEN_TRSHLD20 (at 0xF9959828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES20"
        group.long 0x15820--0x15823 "BAM_P_FIFO_SIZES20 (at 0xF9959820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_20"
        group.long 0x15834--0x15837 "BAM_P_RETR_CNTXT_20 (at 0xF9959834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_20"
        group.long 0x15838--0x1583B "BAM_P_SI_CNTXT_20 (at 0xF9959838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_20"
        group.long 0x15830--0x15833 "BAM_P_DF_CNTXT_20 (at 0xF9959830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_20"
        group.long 0x15804--0x15807 "BAM_P_AU_PSM_CNTXT_1_20 (at 0xF9959804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_20"
        group.long 0x15808--0x1580B "BAM_P_PSM_CNTXT_2_20 (at 0xF9959808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_20"
        group.long 0x1580C--0x1580F "BAM_P_PSM_CNTXT_3_20 (at 0xF995980C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_20"
        group.long 0x15810--0x15813 "BAM_P_PSM_CNTXT_4_20 (at 0xF9959810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_20"
        group.long 0x15814--0x15817 "BAM_P_PSM_CNTXT_5_20 (at 0xF9959814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 20
tree.end
tree "Pipe 21"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL21"
        group.long 0x16000--0x16003 "BAM_P_CTRL21 (at 0xF995A000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST21"
        group.long 0x16004--0x16007 "BAM_P_RST21 (at 0xF995A004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT21"
        group.long 0x16008--0x1600B "BAM_P_HALT21 (at 0xF995A008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG21"
        group.long 0x16030--0x16033 "BAM_P_TRUST_REG21 (at 0xF995A030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS21"
        group.long 0x16010--0x16013 "BAM_P_IRQ_STTS21 (at 0xF995A010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR21"
        group.long 0x16014--0x16017 "BAM_P_IRQ_CLR21 (at 0xF995A014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN21"
        group.long 0x16018--0x1601B "BAM_P_IRQ_EN21 (at 0xF995A018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER21"
        group.long 0x1601C--0x1601F "BAM_P_TIMER21 (at 0xF995A01C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL21"
        group.long 0x16020--0x16023 "BAM_P_TIMER_CTRL21 (at 0xF995A020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND21"
        group.long 0x16024--0x16027 "BAM_P_PRDCR_SDBND21 (at 0xF995A024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND21"
        group.long 0x16028--0x1602B "BAM_P_CNSMR_SDBND21 (at 0xF995A028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR21"
        group.long 0x1682C--0x1682F "BAM_P_EVNT_DEST_ADDR21 (at 0xF995A82C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG21"
        group.long 0x16818--0x1681B "BAM_P_EVNT_REG21 (at 0xF995A818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS21"
        group.long 0x16800--0x16803 "BAM_P_SW_OFSTS21 (at 0xF995A800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR21"
        group.long 0x16824--0x16827 "BAM_P_DATA_FIFO_ADDR21 (at 0xF995A824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR21"
        group.long 0x1681C--0x1681F "BAM_P_DESC_FIFO_ADDR21 (at 0xF995A81C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD21"
        group.long 0x16828--0x1682B "BAM_P_EVNT_GEN_TRSHLD21 (at 0xF995A828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES21"
        group.long 0x16820--0x16823 "BAM_P_FIFO_SIZES21 (at 0xF995A820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_21"
        group.long 0x16834--0x16837 "BAM_P_RETR_CNTXT_21 (at 0xF995A834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_21"
        group.long 0x16838--0x1683B "BAM_P_SI_CNTXT_21 (at 0xF995A838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_21"
        group.long 0x16830--0x16833 "BAM_P_DF_CNTXT_21 (at 0xF995A830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_21"
        group.long 0x16804--0x16807 "BAM_P_AU_PSM_CNTXT_1_21 (at 0xF995A804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_21"
        group.long 0x16808--0x1680B "BAM_P_PSM_CNTXT_2_21 (at 0xF995A808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_21"
        group.long 0x1680C--0x1680F "BAM_P_PSM_CNTXT_3_21 (at 0xF995A80C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_21"
        group.long 0x16810--0x16813 "BAM_P_PSM_CNTXT_4_21 (at 0xF995A810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_21"
        group.long 0x16814--0x16817 "BAM_P_PSM_CNTXT_5_21 (at 0xF995A814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 21
tree.end
tree "Pipe 22"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL22"
        group.long 0x17000--0x17003 "BAM_P_CTRL22 (at 0xF995B000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST22"
        group.long 0x17004--0x17007 "BAM_P_RST22 (at 0xF995B004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT22"
        group.long 0x17008--0x1700B "BAM_P_HALT22 (at 0xF995B008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG22"
        group.long 0x17030--0x17033 "BAM_P_TRUST_REG22 (at 0xF995B030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS22"
        group.long 0x17010--0x17013 "BAM_P_IRQ_STTS22 (at 0xF995B010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR22"
        group.long 0x17014--0x17017 "BAM_P_IRQ_CLR22 (at 0xF995B014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN22"
        group.long 0x17018--0x1701B "BAM_P_IRQ_EN22 (at 0xF995B018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER22"
        group.long 0x1701C--0x1701F "BAM_P_TIMER22 (at 0xF995B01C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL22"
        group.long 0x17020--0x17023 "BAM_P_TIMER_CTRL22 (at 0xF995B020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND22"
        group.long 0x17024--0x17027 "BAM_P_PRDCR_SDBND22 (at 0xF995B024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND22"
        group.long 0x17028--0x1702B "BAM_P_CNSMR_SDBND22 (at 0xF995B028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR22"
        group.long 0x1782C--0x1782F "BAM_P_EVNT_DEST_ADDR22 (at 0xF995B82C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG22"
        group.long 0x17818--0x1781B "BAM_P_EVNT_REG22 (at 0xF995B818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS22"
        group.long 0x17800--0x17803 "BAM_P_SW_OFSTS22 (at 0xF995B800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR22"
        group.long 0x17824--0x17827 "BAM_P_DATA_FIFO_ADDR22 (at 0xF995B824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR22"
        group.long 0x1781C--0x1781F "BAM_P_DESC_FIFO_ADDR22 (at 0xF995B81C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD22"
        group.long 0x17828--0x1782B "BAM_P_EVNT_GEN_TRSHLD22 (at 0xF995B828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES22"
        group.long 0x17820--0x17823 "BAM_P_FIFO_SIZES22 (at 0xF995B820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_22"
        group.long 0x17834--0x17837 "BAM_P_RETR_CNTXT_22 (at 0xF995B834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_22"
        group.long 0x17838--0x1783B "BAM_P_SI_CNTXT_22 (at 0xF995B838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_22"
        group.long 0x17830--0x17833 "BAM_P_DF_CNTXT_22 (at 0xF995B830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_22"
        group.long 0x17804--0x17807 "BAM_P_AU_PSM_CNTXT_1_22 (at 0xF995B804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_22"
        group.long 0x17808--0x1780B "BAM_P_PSM_CNTXT_2_22 (at 0xF995B808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_22"
        group.long 0x1780C--0x1780F "BAM_P_PSM_CNTXT_3_22 (at 0xF995B80C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_22"
        group.long 0x17810--0x17813 "BAM_P_PSM_CNTXT_4_22 (at 0xF995B810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_22"
        group.long 0x17814--0x17817 "BAM_P_PSM_CNTXT_5_22 (at 0xF995B814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 22
tree.end
tree "Pipe 23"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL23"
        group.long 0x18000--0x18003 "BAM_P_CTRL23 (at 0xF995C000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST23"
        group.long 0x18004--0x18007 "BAM_P_RST23 (at 0xF995C004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT23"
        group.long 0x18008--0x1800B "BAM_P_HALT23 (at 0xF995C008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG23"
        group.long 0x18030--0x18033 "BAM_P_TRUST_REG23 (at 0xF995C030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS23"
        group.long 0x18010--0x18013 "BAM_P_IRQ_STTS23 (at 0xF995C010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR23"
        group.long 0x18014--0x18017 "BAM_P_IRQ_CLR23 (at 0xF995C014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN23"
        group.long 0x18018--0x1801B "BAM_P_IRQ_EN23 (at 0xF995C018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER23"
        group.long 0x1801C--0x1801F "BAM_P_TIMER23 (at 0xF995C01C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL23"
        group.long 0x18020--0x18023 "BAM_P_TIMER_CTRL23 (at 0xF995C020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND23"
        group.long 0x18024--0x18027 "BAM_P_PRDCR_SDBND23 (at 0xF995C024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND23"
        group.long 0x18028--0x1802B "BAM_P_CNSMR_SDBND23 (at 0xF995C028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR23"
        group.long 0x1882C--0x1882F "BAM_P_EVNT_DEST_ADDR23 (at 0xF995C82C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG23"
        group.long 0x18818--0x1881B "BAM_P_EVNT_REG23 (at 0xF995C818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS23"
        group.long 0x18800--0x18803 "BAM_P_SW_OFSTS23 (at 0xF995C800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR23"
        group.long 0x18824--0x18827 "BAM_P_DATA_FIFO_ADDR23 (at 0xF995C824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR23"
        group.long 0x1881C--0x1881F "BAM_P_DESC_FIFO_ADDR23 (at 0xF995C81C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD23"
        group.long 0x18828--0x1882B "BAM_P_EVNT_GEN_TRSHLD23 (at 0xF995C828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES23"
        group.long 0x18820--0x18823 "BAM_P_FIFO_SIZES23 (at 0xF995C820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_23"
        group.long 0x18834--0x18837 "BAM_P_RETR_CNTXT_23 (at 0xF995C834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_23"
        group.long 0x18838--0x1883B "BAM_P_SI_CNTXT_23 (at 0xF995C838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_23"
        group.long 0x18830--0x18833 "BAM_P_DF_CNTXT_23 (at 0xF995C830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_23"
        group.long 0x18804--0x18807 "BAM_P_AU_PSM_CNTXT_1_23 (at 0xF995C804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_23"
        group.long 0x18808--0x1880B "BAM_P_PSM_CNTXT_2_23 (at 0xF995C808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_23"
        group.long 0x1880C--0x1880F "BAM_P_PSM_CNTXT_3_23 (at 0xF995C80C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_23"
        group.long 0x18810--0x18813 "BAM_P_PSM_CNTXT_4_23 (at 0xF995C810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_23"
        group.long 0x18814--0x18817 "BAM_P_PSM_CNTXT_5_23 (at 0xF995C814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 23
tree.end
tree.end
;Block Per Data Ends

base ad:0xF9984000
tree "BAMDMA_BAM"
tree "BAM Control Registers"
      tree "BAM_CTRL"
        group.long 0x0--0x3 "BAM_CTRL (at 0xF9984000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x13 " [   19]   CACHE_MISS_ERR_RESP_EN                   = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11--0x12 " [18:17]   LOCAL_CLK_GATING                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   IBC_DISABLE                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0xF " [   15]   BAM_CACHED_DESC_STORE                    = "  "0,1"
        textline ""
        bitfld.long 0x0 0xD--0xE " [14:13]   BAM_DESC_CACHE_SEL                       = "  "0,1,2,3"
        textline ""
        hexmask.long.word 0x0 0x5--0xB 1  " [11:05]   BAM_TESTBUS_SEL                          = " 
        textline ""
        bitfld.long 0x0 0x4 " [   04]   BAM_EN_ACCUM                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_EN                                   = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   BAM_SW_RST                               = "  "0,1"
        textline ""
      tree.end
      tree "BAM_REVISION"
        group.long 0x4--0x7 "BAM_REVISION (at 0xF9984004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x18--0x1F 1  " [31:24]   INACTIV_TMR_BASE                         = " 
        textline ""
        bitfld.long 0x0 0x17 " [   23]   CMD_DESC_EN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15--0x16 " [22:21]   DESC_CACHE_DEPTH                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   NUM_INACTIV_TMRS                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x13 " [   19]   INACTIV_TMRS_EXST                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x12 " [   18]   HIGH_FREQUENCY_BAM                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11 " [   17]   BAM_HAS_NO_BYPASS                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   SECURED                                  = "  "0,1"
        textline ""
        bitfld.long 0x0 0xF " [   15]   USE_VMIDMT                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0xE " [   14]   AXI_ACTIVE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0xD " [   13]   CE_BUFFER_SIZE                           = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x8--0xB 1  " [11:08]   NUM_EES                                  = " 
        textline ""
        hexmask.long.word 0x0 0x0--0x7 1  " [07:00]   REVISION                                 = " 
        textline ""
      tree.end
      tree "BAM_SW_VERSION"
        group.long 0x80--0x83 "BAM_SW_VERSION (at 0xF9984080) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x1C--0x1F 1  " [31:28]   MAJOR                                    = " 
        textline ""
        hexmask.long.word 0x0 0x10--0x1B 1  " [27:16]   MINOR                                    = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   STEP                                     = " 
        textline ""
      tree.end
      tree "BAM_NUM_PIPES"
        group.long 0x3C--0x3F "BAM_NUM_PIPES (at 0xF998403C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x18--0x1F 1  " [31:24]   BAM_NON_PIPE_GRP                         = " 
        textline ""
        hexmask.long.word 0x0 0x10--0x17 1  " [23:16]   PERIPH_NON_PIPE_GRP                      = " 
        textline ""
        hexmask.long.word 0x0 0x0--0x7 1  " [07:00]   BAM_NUM_PIPES                            = " 
        textline ""
      tree.end
      tree "BAM_TIMER"
        group.long 0x40--0x43 "BAM_TIMER (at 0xF9984040) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   TIMER                                    = " 
        textline ""
      tree.end
      tree "BAM_TIMER_CTRL"
        group.long 0x44--0x47 "BAM_TIMER_CTRL (at 0xF9984044) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   TIMER_RST                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   TIMER_RUN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   TIMER_MODE                               = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   TIMER_TRSHLD                             = " 
        textline ""
      tree.end
      tree "BAM_DESC_CNT_TRSHLD"
        group.long 0x8--0xB "BAM_DESC_CNT_TRSHLD (at 0xF9984008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   CNT_TRSHLD                               = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS"
        group.long 0xC--0xF "BAM_IRQ_SRCS (at 0xF998400C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK"
        group.long 0x10--0x13 "BAM_IRQ_SRCS_MSK (at 0xF9984010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED"
        group.long 0x30--0x33 "BAM_IRQ_SRCS_UNMASKED (at 0xF9984030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_STTS"
        group.long 0x14--0x17 "BAM_IRQ_STTS (at 0xF9984014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x4 " [   04]   BAM_TIMER_IRQ                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   BAM_EMPTY_IRQ                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_ERROR_IRQ                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_HRESP_ERR_IRQ                        = "  "0,1"
        textline ""
      tree.end
      tree "BAM_IRQ_CLR"
        group.long 0x18--0x1B "BAM_IRQ_CLR (at 0xF9984018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x4 " [   04]   BAM_TIMER_CLR                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   BAM_EMPTY_CLR                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_ERROR_CLR                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_HRESP_ERR_CLR                        = "  "0,1"
        textline ""
      tree.end
      tree "BAM_IRQ_EN"
        group.long 0x1C--0x1F "BAM_IRQ_EN (at 0xF998401C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x4 " [   04]   BAM_TIMER_EN                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   BAM_EMPTY_EN                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_ERROR_EN                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_HRESP_ERR_EN                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_AHB_MASTER_ERR_CTRLS"
        group.long 0x24--0x27 "BAM_AHB_MASTER_ERR_CTRLS (at 0xF9984024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x12--0x16 1  " [22:18]   BAM_ERR_HVMID                            = " 
        textline ""
        bitfld.long 0x0 0x11 " [   17]   BAM_ERR_DIRECT_MODE                      = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0xC--0x10 1  " [16:12]   BAM_ERR_HCID                             = " 
        textline ""
        hexmask.long.word 0x0 0x8--0xB 1  " [11:08]   BAM_ERR_HPROT                            = " 
        textline ""
        bitfld.long 0x0 0x5--0x7 " [07:05]   BAM_ERR_HBURST                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x3--0x4 " [04:03]   BAM_ERR_HSIZE                            = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_ERR_HWRITE                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0--0x1 " [01:00]   BAM_ERR_HTRANS                           = "  "0,1,2,3"
        textline ""
      tree.end
      tree "BAM_AHB_MASTER_ERR_ADDR"
        group.long 0x28--0x2B "BAM_AHB_MASTER_ERR_ADDR (at 0xF9984028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   BAM_ERR_ADDR                             = " 
        textline ""
      tree.end
      tree "BAM_AHB_MASTER_ERR_DATA"
        group.long 0x2C--0x2F "BAM_AHB_MASTER_ERR_DATA (at 0xF998402C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   BAM_ERR_DATA                             = " 
        textline ""
      tree.end
      tree "BAM_TRUST_REG"
        group.long 0x70--0x73 "BAM_TRUST_REG (at 0xF9984070) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0xD " [   13]   LOCK_EE_CTRL                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_VMID                                 = " 
        textline ""
        bitfld.long 0x0 0x7 " [   07]   BAM_RST_BLOCK                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_EE                                   = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_TEST_BUS_SEL"
        group.long 0x74--0x77 "BAM_TEST_BUS_SEL (at 0xF9984074) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x15 " [   21]   SW_EVENTS_ZERO                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x13--0x14 " [20:19]   SW_EVENTS_SEL                            = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x12 " [   18]   BAM_DATA_ERASE                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11 " [   17]   BAM_DATA_FLUSH                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   BAM_CLK_ALWAYS_ON                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x0--0x6 1  " [06:00]   BAM_TESTBUS_SEL                          = " 
        textline ""
      tree.end
      tree "BAM_TEST_BUS_REG"
        group.long 0x78--0x7B "BAM_TEST_BUS_REG (at 0xF9984078) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   BAM_TESTBUS_REG                          = " 
        textline ""
      tree.end
      tree "BAM_CNFG_BITS"
        group.long 0x7C--0x7F "BAM_CNFG_BITS (at 0xF998407C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1C " [   28]   BAM_ZLT_W_CD_SUPPORT                     = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1B " [   27]   BAM_CD_ENABLE                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1A " [   26]   BAM_AU_ACCUMED                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x19 " [   25]   BAM_PSM_P_HD_DATA                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_REG_P_EN                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_WB_DSC_AVL_P_RST                     = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_WB_RETR_SVPNT                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_WB_CSW_ACK_IDL                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_WB_BLK_CSW                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x13 " [   19]   BAM_WB_P_RES                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x12 " [   18]   BAM_SI_P_RES                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11 " [   17]   BAM_AU_P_RES                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   BAM_PSM_P_RES                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0xF " [   15]   BAM_PSM_CSW_REQ                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0xE " [   14]   BAM_SB_CLK_REQ                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0xD " [   13]   BAM_IBC_DISABLE                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0xC " [   12]   BAM_NO_EXT_P_RST                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0xB " [   11]   BAM_FULL_PIPE                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   BAM_ADML_SYNC_BRIDGE                     = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_PIPE_CNFG                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_ADML_DEEP_CONS_FIFO                  = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   BAM_ADML_INCR4_EN_N                      = "  "0,1"
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE0"
        group.long 0x800--0x803 "BAM_IRQ_SRCS_EE0 (at 0xF9984800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE1"
        group.long 0x880--0x883 "BAM_IRQ_SRCS_EE1 (at 0xF9984880) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE2"
        group.long 0x900--0x903 "BAM_IRQ_SRCS_EE2 (at 0xF9984900) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE3"
        group.long 0x980--0x983 "BAM_IRQ_SRCS_EE3 (at 0xF9984980) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE4"
        group.long 0xA00--0xA03 "BAM_IRQ_SRCS_EE4 (at 0xF9984A00) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE5"
        group.long 0xA80--0xA83 "BAM_IRQ_SRCS_EE5 (at 0xF9984A80) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE6"
        group.long 0xB00--0xB03 "BAM_IRQ_SRCS_EE6 (at 0xF9984B00) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE7"
        group.long 0xB80--0xB83 "BAM_IRQ_SRCS_EE7 (at 0xF9984B80) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE0"
        group.long 0x804--0x807 "BAM_IRQ_SRCS_MSK_EE0 (at 0xF9984804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE1"
        group.long 0x884--0x887 "BAM_IRQ_SRCS_MSK_EE1 (at 0xF9984884) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE2"
        group.long 0x904--0x907 "BAM_IRQ_SRCS_MSK_EE2 (at 0xF9984904) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE3"
        group.long 0x984--0x987 "BAM_IRQ_SRCS_MSK_EE3 (at 0xF9984984) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE4"
        group.long 0xA04--0xA07 "BAM_IRQ_SRCS_MSK_EE4 (at 0xF9984A04) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE5"
        group.long 0xA84--0xA87 "BAM_IRQ_SRCS_MSK_EE5 (at 0xF9984A84) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE6"
        group.long 0xB04--0xB07 "BAM_IRQ_SRCS_MSK_EE6 (at 0xF9984B04) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE7"
        group.long 0xB84--0xB87 "BAM_IRQ_SRCS_MSK_EE7 (at 0xF9984B84) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE0"
        group.long 0x808--0x80B "BAM_IRQ_SRCS_UNMASKED_EE0 (at 0xF9984808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE1"
        group.long 0x888--0x88B "BAM_IRQ_SRCS_UNMASKED_EE1 (at 0xF9984888) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE2"
        group.long 0x908--0x90B "BAM_IRQ_SRCS_UNMASKED_EE2 (at 0xF9984908) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE3"
        group.long 0x988--0x98B "BAM_IRQ_SRCS_UNMASKED_EE3 (at 0xF9984988) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE4"
        group.long 0xA08--0xA0B "BAM_IRQ_SRCS_UNMASKED_EE4 (at 0xF9984A08) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE5"
        group.long 0xA88--0xA8B "BAM_IRQ_SRCS_UNMASKED_EE5 (at 0xF9984A88) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE6"
        group.long 0xB08--0xB0B "BAM_IRQ_SRCS_UNMASKED_EE6 (at 0xF9984B08) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE7"
        group.long 0xB88--0xB8B "BAM_IRQ_SRCS_UNMASKED_EE7 (at 0xF9984B88) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
;End of BAM Control Registers
tree.end
tree "Pipe 0"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL0"
        group.long 0x1000--0x1003 "BAM_P_CTRL0 (at 0xF9985000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST0"
        group.long 0x1004--0x1007 "BAM_P_RST0 (at 0xF9985004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT0"
        group.long 0x1008--0x100B "BAM_P_HALT0 (at 0xF9985008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG0"
        group.long 0x1030--0x1033 "BAM_P_TRUST_REG0 (at 0xF9985030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS0"
        group.long 0x1010--0x1013 "BAM_P_IRQ_STTS0 (at 0xF9985010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR0"
        group.long 0x1014--0x1017 "BAM_P_IRQ_CLR0 (at 0xF9985014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN0"
        group.long 0x1018--0x101B "BAM_P_IRQ_EN0 (at 0xF9985018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER0"
        group.long 0x101C--0x101F "BAM_P_TIMER0 (at 0xF998501C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL0"
        group.long 0x1020--0x1023 "BAM_P_TIMER_CTRL0 (at 0xF9985020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND0"
        group.long 0x1024--0x1027 "BAM_P_PRDCR_SDBND0 (at 0xF9985024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND0"
        group.long 0x1028--0x102B "BAM_P_CNSMR_SDBND0 (at 0xF9985028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR0"
        group.long 0x182C--0x182F "BAM_P_EVNT_DEST_ADDR0 (at 0xF998582C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG0"
        group.long 0x1818--0x181B "BAM_P_EVNT_REG0 (at 0xF9985818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS0"
        group.long 0x1800--0x1803 "BAM_P_SW_OFSTS0 (at 0xF9985800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR0"
        group.long 0x1824--0x1827 "BAM_P_DATA_FIFO_ADDR0 (at 0xF9985824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR0"
        group.long 0x181C--0x181F "BAM_P_DESC_FIFO_ADDR0 (at 0xF998581C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD0"
        group.long 0x1828--0x182B "BAM_P_EVNT_GEN_TRSHLD0 (at 0xF9985828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES0"
        group.long 0x1820--0x1823 "BAM_P_FIFO_SIZES0 (at 0xF9985820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_0"
        group.long 0x1834--0x1837 "BAM_P_RETR_CNTXT_0 (at 0xF9985834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_0"
        group.long 0x1838--0x183B "BAM_P_SI_CNTXT_0 (at 0xF9985838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_0"
        group.long 0x1830--0x1833 "BAM_P_DF_CNTXT_0 (at 0xF9985830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_0"
        group.long 0x1804--0x1807 "BAM_P_AU_PSM_CNTXT_1_0 (at 0xF9985804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_0"
        group.long 0x1808--0x180B "BAM_P_PSM_CNTXT_2_0 (at 0xF9985808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_0"
        group.long 0x180C--0x180F "BAM_P_PSM_CNTXT_3_0 (at 0xF998580C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_0"
        group.long 0x1810--0x1813 "BAM_P_PSM_CNTXT_4_0 (at 0xF9985810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_0"
        group.long 0x1814--0x1817 "BAM_P_PSM_CNTXT_5_0 (at 0xF9985814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 0
tree.end
tree "Pipe 1"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL1"
        group.long 0x2000--0x2003 "BAM_P_CTRL1 (at 0xF9986000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST1"
        group.long 0x2004--0x2007 "BAM_P_RST1 (at 0xF9986004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT1"
        group.long 0x2008--0x200B "BAM_P_HALT1 (at 0xF9986008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG1"
        group.long 0x2030--0x2033 "BAM_P_TRUST_REG1 (at 0xF9986030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS1"
        group.long 0x2010--0x2013 "BAM_P_IRQ_STTS1 (at 0xF9986010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR1"
        group.long 0x2014--0x2017 "BAM_P_IRQ_CLR1 (at 0xF9986014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN1"
        group.long 0x2018--0x201B "BAM_P_IRQ_EN1 (at 0xF9986018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER1"
        group.long 0x201C--0x201F "BAM_P_TIMER1 (at 0xF998601C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL1"
        group.long 0x2020--0x2023 "BAM_P_TIMER_CTRL1 (at 0xF9986020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND1"
        group.long 0x2024--0x2027 "BAM_P_PRDCR_SDBND1 (at 0xF9986024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND1"
        group.long 0x2028--0x202B "BAM_P_CNSMR_SDBND1 (at 0xF9986028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR1"
        group.long 0x282C--0x282F "BAM_P_EVNT_DEST_ADDR1 (at 0xF998682C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG1"
        group.long 0x2818--0x281B "BAM_P_EVNT_REG1 (at 0xF9986818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS1"
        group.long 0x2800--0x2803 "BAM_P_SW_OFSTS1 (at 0xF9986800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR1"
        group.long 0x2824--0x2827 "BAM_P_DATA_FIFO_ADDR1 (at 0xF9986824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR1"
        group.long 0x281C--0x281F "BAM_P_DESC_FIFO_ADDR1 (at 0xF998681C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD1"
        group.long 0x2828--0x282B "BAM_P_EVNT_GEN_TRSHLD1 (at 0xF9986828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES1"
        group.long 0x2820--0x2823 "BAM_P_FIFO_SIZES1 (at 0xF9986820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_1"
        group.long 0x2834--0x2837 "BAM_P_RETR_CNTXT_1 (at 0xF9986834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_1"
        group.long 0x2838--0x283B "BAM_P_SI_CNTXT_1 (at 0xF9986838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_1"
        group.long 0x2830--0x2833 "BAM_P_DF_CNTXT_1 (at 0xF9986830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_1"
        group.long 0x2804--0x2807 "BAM_P_AU_PSM_CNTXT_1_1 (at 0xF9986804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_1"
        group.long 0x2808--0x280B "BAM_P_PSM_CNTXT_2_1 (at 0xF9986808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_1"
        group.long 0x280C--0x280F "BAM_P_PSM_CNTXT_3_1 (at 0xF998680C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_1"
        group.long 0x2810--0x2813 "BAM_P_PSM_CNTXT_4_1 (at 0xF9986810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_1"
        group.long 0x2814--0x2817 "BAM_P_PSM_CNTXT_5_1 (at 0xF9986814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 1
tree.end
tree "Pipe 2"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL2"
        group.long 0x3000--0x3003 "BAM_P_CTRL2 (at 0xF9987000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST2"
        group.long 0x3004--0x3007 "BAM_P_RST2 (at 0xF9987004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT2"
        group.long 0x3008--0x300B "BAM_P_HALT2 (at 0xF9987008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG2"
        group.long 0x3030--0x3033 "BAM_P_TRUST_REG2 (at 0xF9987030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS2"
        group.long 0x3010--0x3013 "BAM_P_IRQ_STTS2 (at 0xF9987010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR2"
        group.long 0x3014--0x3017 "BAM_P_IRQ_CLR2 (at 0xF9987014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN2"
        group.long 0x3018--0x301B "BAM_P_IRQ_EN2 (at 0xF9987018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER2"
        group.long 0x301C--0x301F "BAM_P_TIMER2 (at 0xF998701C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL2"
        group.long 0x3020--0x3023 "BAM_P_TIMER_CTRL2 (at 0xF9987020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND2"
        group.long 0x3024--0x3027 "BAM_P_PRDCR_SDBND2 (at 0xF9987024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND2"
        group.long 0x3028--0x302B "BAM_P_CNSMR_SDBND2 (at 0xF9987028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR2"
        group.long 0x382C--0x382F "BAM_P_EVNT_DEST_ADDR2 (at 0xF998782C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG2"
        group.long 0x3818--0x381B "BAM_P_EVNT_REG2 (at 0xF9987818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS2"
        group.long 0x3800--0x3803 "BAM_P_SW_OFSTS2 (at 0xF9987800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR2"
        group.long 0x3824--0x3827 "BAM_P_DATA_FIFO_ADDR2 (at 0xF9987824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR2"
        group.long 0x381C--0x381F "BAM_P_DESC_FIFO_ADDR2 (at 0xF998781C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD2"
        group.long 0x3828--0x382B "BAM_P_EVNT_GEN_TRSHLD2 (at 0xF9987828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES2"
        group.long 0x3820--0x3823 "BAM_P_FIFO_SIZES2 (at 0xF9987820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_2"
        group.long 0x3834--0x3837 "BAM_P_RETR_CNTXT_2 (at 0xF9987834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_2"
        group.long 0x3838--0x383B "BAM_P_SI_CNTXT_2 (at 0xF9987838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_2"
        group.long 0x3830--0x3833 "BAM_P_DF_CNTXT_2 (at 0xF9987830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_2"
        group.long 0x3804--0x3807 "BAM_P_AU_PSM_CNTXT_1_2 (at 0xF9987804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_2"
        group.long 0x3808--0x380B "BAM_P_PSM_CNTXT_2_2 (at 0xF9987808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_2"
        group.long 0x380C--0x380F "BAM_P_PSM_CNTXT_3_2 (at 0xF998780C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_2"
        group.long 0x3810--0x3813 "BAM_P_PSM_CNTXT_4_2 (at 0xF9987810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_2"
        group.long 0x3814--0x3817 "BAM_P_PSM_CNTXT_5_2 (at 0xF9987814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 2
tree.end
tree "Pipe 3"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL3"
        group.long 0x4000--0x4003 "BAM_P_CTRL3 (at 0xF9988000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST3"
        group.long 0x4004--0x4007 "BAM_P_RST3 (at 0xF9988004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT3"
        group.long 0x4008--0x400B "BAM_P_HALT3 (at 0xF9988008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG3"
        group.long 0x4030--0x4033 "BAM_P_TRUST_REG3 (at 0xF9988030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS3"
        group.long 0x4010--0x4013 "BAM_P_IRQ_STTS3 (at 0xF9988010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR3"
        group.long 0x4014--0x4017 "BAM_P_IRQ_CLR3 (at 0xF9988014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN3"
        group.long 0x4018--0x401B "BAM_P_IRQ_EN3 (at 0xF9988018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER3"
        group.long 0x401C--0x401F "BAM_P_TIMER3 (at 0xF998801C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL3"
        group.long 0x4020--0x4023 "BAM_P_TIMER_CTRL3 (at 0xF9988020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND3"
        group.long 0x4024--0x4027 "BAM_P_PRDCR_SDBND3 (at 0xF9988024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND3"
        group.long 0x4028--0x402B "BAM_P_CNSMR_SDBND3 (at 0xF9988028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR3"
        group.long 0x482C--0x482F "BAM_P_EVNT_DEST_ADDR3 (at 0xF998882C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG3"
        group.long 0x4818--0x481B "BAM_P_EVNT_REG3 (at 0xF9988818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS3"
        group.long 0x4800--0x4803 "BAM_P_SW_OFSTS3 (at 0xF9988800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR3"
        group.long 0x4824--0x4827 "BAM_P_DATA_FIFO_ADDR3 (at 0xF9988824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR3"
        group.long 0x481C--0x481F "BAM_P_DESC_FIFO_ADDR3 (at 0xF998881C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD3"
        group.long 0x4828--0x482B "BAM_P_EVNT_GEN_TRSHLD3 (at 0xF9988828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES3"
        group.long 0x4820--0x4823 "BAM_P_FIFO_SIZES3 (at 0xF9988820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_3"
        group.long 0x4834--0x4837 "BAM_P_RETR_CNTXT_3 (at 0xF9988834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_3"
        group.long 0x4838--0x483B "BAM_P_SI_CNTXT_3 (at 0xF9988838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_3"
        group.long 0x4830--0x4833 "BAM_P_DF_CNTXT_3 (at 0xF9988830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_3"
        group.long 0x4804--0x4807 "BAM_P_AU_PSM_CNTXT_1_3 (at 0xF9988804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_3"
        group.long 0x4808--0x480B "BAM_P_PSM_CNTXT_2_3 (at 0xF9988808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_3"
        group.long 0x480C--0x480F "BAM_P_PSM_CNTXT_3_3 (at 0xF998880C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_3"
        group.long 0x4810--0x4813 "BAM_P_PSM_CNTXT_4_3 (at 0xF9988810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_3"
        group.long 0x4814--0x4817 "BAM_P_PSM_CNTXT_5_3 (at 0xF9988814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 3
tree.end
tree "Pipe 4"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL4"
        group.long 0x5000--0x5003 "BAM_P_CTRL4 (at 0xF9989000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST4"
        group.long 0x5004--0x5007 "BAM_P_RST4 (at 0xF9989004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT4"
        group.long 0x5008--0x500B "BAM_P_HALT4 (at 0xF9989008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG4"
        group.long 0x5030--0x5033 "BAM_P_TRUST_REG4 (at 0xF9989030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS4"
        group.long 0x5010--0x5013 "BAM_P_IRQ_STTS4 (at 0xF9989010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR4"
        group.long 0x5014--0x5017 "BAM_P_IRQ_CLR4 (at 0xF9989014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN4"
        group.long 0x5018--0x501B "BAM_P_IRQ_EN4 (at 0xF9989018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER4"
        group.long 0x501C--0x501F "BAM_P_TIMER4 (at 0xF998901C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL4"
        group.long 0x5020--0x5023 "BAM_P_TIMER_CTRL4 (at 0xF9989020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND4"
        group.long 0x5024--0x5027 "BAM_P_PRDCR_SDBND4 (at 0xF9989024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND4"
        group.long 0x5028--0x502B "BAM_P_CNSMR_SDBND4 (at 0xF9989028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR4"
        group.long 0x582C--0x582F "BAM_P_EVNT_DEST_ADDR4 (at 0xF998982C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG4"
        group.long 0x5818--0x581B "BAM_P_EVNT_REG4 (at 0xF9989818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS4"
        group.long 0x5800--0x5803 "BAM_P_SW_OFSTS4 (at 0xF9989800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR4"
        group.long 0x5824--0x5827 "BAM_P_DATA_FIFO_ADDR4 (at 0xF9989824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR4"
        group.long 0x581C--0x581F "BAM_P_DESC_FIFO_ADDR4 (at 0xF998981C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD4"
        group.long 0x5828--0x582B "BAM_P_EVNT_GEN_TRSHLD4 (at 0xF9989828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES4"
        group.long 0x5820--0x5823 "BAM_P_FIFO_SIZES4 (at 0xF9989820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_4"
        group.long 0x5834--0x5837 "BAM_P_RETR_CNTXT_4 (at 0xF9989834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_4"
        group.long 0x5838--0x583B "BAM_P_SI_CNTXT_4 (at 0xF9989838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_4"
        group.long 0x5830--0x5833 "BAM_P_DF_CNTXT_4 (at 0xF9989830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_4"
        group.long 0x5804--0x5807 "BAM_P_AU_PSM_CNTXT_1_4 (at 0xF9989804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_4"
        group.long 0x5808--0x580B "BAM_P_PSM_CNTXT_2_4 (at 0xF9989808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_4"
        group.long 0x580C--0x580F "BAM_P_PSM_CNTXT_3_4 (at 0xF998980C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_4"
        group.long 0x5810--0x5813 "BAM_P_PSM_CNTXT_4_4 (at 0xF9989810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_4"
        group.long 0x5814--0x5817 "BAM_P_PSM_CNTXT_5_4 (at 0xF9989814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 4
tree.end
tree "Pipe 5"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL5"
        group.long 0x6000--0x6003 "BAM_P_CTRL5 (at 0xF998A000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST5"
        group.long 0x6004--0x6007 "BAM_P_RST5 (at 0xF998A004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT5"
        group.long 0x6008--0x600B "BAM_P_HALT5 (at 0xF998A008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG5"
        group.long 0x6030--0x6033 "BAM_P_TRUST_REG5 (at 0xF998A030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS5"
        group.long 0x6010--0x6013 "BAM_P_IRQ_STTS5 (at 0xF998A010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR5"
        group.long 0x6014--0x6017 "BAM_P_IRQ_CLR5 (at 0xF998A014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN5"
        group.long 0x6018--0x601B "BAM_P_IRQ_EN5 (at 0xF998A018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER5"
        group.long 0x601C--0x601F "BAM_P_TIMER5 (at 0xF998A01C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL5"
        group.long 0x6020--0x6023 "BAM_P_TIMER_CTRL5 (at 0xF998A020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND5"
        group.long 0x6024--0x6027 "BAM_P_PRDCR_SDBND5 (at 0xF998A024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND5"
        group.long 0x6028--0x602B "BAM_P_CNSMR_SDBND5 (at 0xF998A028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR5"
        group.long 0x682C--0x682F "BAM_P_EVNT_DEST_ADDR5 (at 0xF998A82C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG5"
        group.long 0x6818--0x681B "BAM_P_EVNT_REG5 (at 0xF998A818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS5"
        group.long 0x6800--0x6803 "BAM_P_SW_OFSTS5 (at 0xF998A800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR5"
        group.long 0x6824--0x6827 "BAM_P_DATA_FIFO_ADDR5 (at 0xF998A824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR5"
        group.long 0x681C--0x681F "BAM_P_DESC_FIFO_ADDR5 (at 0xF998A81C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD5"
        group.long 0x6828--0x682B "BAM_P_EVNT_GEN_TRSHLD5 (at 0xF998A828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES5"
        group.long 0x6820--0x6823 "BAM_P_FIFO_SIZES5 (at 0xF998A820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_5"
        group.long 0x6834--0x6837 "BAM_P_RETR_CNTXT_5 (at 0xF998A834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_5"
        group.long 0x6838--0x683B "BAM_P_SI_CNTXT_5 (at 0xF998A838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_5"
        group.long 0x6830--0x6833 "BAM_P_DF_CNTXT_5 (at 0xF998A830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_5"
        group.long 0x6804--0x6807 "BAM_P_AU_PSM_CNTXT_1_5 (at 0xF998A804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_5"
        group.long 0x6808--0x680B "BAM_P_PSM_CNTXT_2_5 (at 0xF998A808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_5"
        group.long 0x680C--0x680F "BAM_P_PSM_CNTXT_3_5 (at 0xF998A80C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_5"
        group.long 0x6810--0x6813 "BAM_P_PSM_CNTXT_4_5 (at 0xF998A810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_5"
        group.long 0x6814--0x6817 "BAM_P_PSM_CNTXT_5_5 (at 0xF998A814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 5
tree.end
tree "Pipe 6"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL6"
        group.long 0x7000--0x7003 "BAM_P_CTRL6 (at 0xF998B000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST6"
        group.long 0x7004--0x7007 "BAM_P_RST6 (at 0xF998B004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT6"
        group.long 0x7008--0x700B "BAM_P_HALT6 (at 0xF998B008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG6"
        group.long 0x7030--0x7033 "BAM_P_TRUST_REG6 (at 0xF998B030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS6"
        group.long 0x7010--0x7013 "BAM_P_IRQ_STTS6 (at 0xF998B010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR6"
        group.long 0x7014--0x7017 "BAM_P_IRQ_CLR6 (at 0xF998B014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN6"
        group.long 0x7018--0x701B "BAM_P_IRQ_EN6 (at 0xF998B018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER6"
        group.long 0x701C--0x701F "BAM_P_TIMER6 (at 0xF998B01C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL6"
        group.long 0x7020--0x7023 "BAM_P_TIMER_CTRL6 (at 0xF998B020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND6"
        group.long 0x7024--0x7027 "BAM_P_PRDCR_SDBND6 (at 0xF998B024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND6"
        group.long 0x7028--0x702B "BAM_P_CNSMR_SDBND6 (at 0xF998B028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR6"
        group.long 0x782C--0x782F "BAM_P_EVNT_DEST_ADDR6 (at 0xF998B82C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG6"
        group.long 0x7818--0x781B "BAM_P_EVNT_REG6 (at 0xF998B818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS6"
        group.long 0x7800--0x7803 "BAM_P_SW_OFSTS6 (at 0xF998B800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR6"
        group.long 0x7824--0x7827 "BAM_P_DATA_FIFO_ADDR6 (at 0xF998B824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR6"
        group.long 0x781C--0x781F "BAM_P_DESC_FIFO_ADDR6 (at 0xF998B81C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD6"
        group.long 0x7828--0x782B "BAM_P_EVNT_GEN_TRSHLD6 (at 0xF998B828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES6"
        group.long 0x7820--0x7823 "BAM_P_FIFO_SIZES6 (at 0xF998B820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_6"
        group.long 0x7834--0x7837 "BAM_P_RETR_CNTXT_6 (at 0xF998B834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_6"
        group.long 0x7838--0x783B "BAM_P_SI_CNTXT_6 (at 0xF998B838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_6"
        group.long 0x7830--0x7833 "BAM_P_DF_CNTXT_6 (at 0xF998B830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_6"
        group.long 0x7804--0x7807 "BAM_P_AU_PSM_CNTXT_1_6 (at 0xF998B804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_6"
        group.long 0x7808--0x780B "BAM_P_PSM_CNTXT_2_6 (at 0xF998B808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_6"
        group.long 0x780C--0x780F "BAM_P_PSM_CNTXT_3_6 (at 0xF998B80C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_6"
        group.long 0x7810--0x7813 "BAM_P_PSM_CNTXT_4_6 (at 0xF998B810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_6"
        group.long 0x7814--0x7817 "BAM_P_PSM_CNTXT_5_6 (at 0xF998B814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 6
tree.end
tree "Pipe 7"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL7"
        group.long 0x8000--0x8003 "BAM_P_CTRL7 (at 0xF998C000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST7"
        group.long 0x8004--0x8007 "BAM_P_RST7 (at 0xF998C004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT7"
        group.long 0x8008--0x800B "BAM_P_HALT7 (at 0xF998C008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG7"
        group.long 0x8030--0x8033 "BAM_P_TRUST_REG7 (at 0xF998C030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS7"
        group.long 0x8010--0x8013 "BAM_P_IRQ_STTS7 (at 0xF998C010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR7"
        group.long 0x8014--0x8017 "BAM_P_IRQ_CLR7 (at 0xF998C014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN7"
        group.long 0x8018--0x801B "BAM_P_IRQ_EN7 (at 0xF998C018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER7"
        group.long 0x801C--0x801F "BAM_P_TIMER7 (at 0xF998C01C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL7"
        group.long 0x8020--0x8023 "BAM_P_TIMER_CTRL7 (at 0xF998C020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND7"
        group.long 0x8024--0x8027 "BAM_P_PRDCR_SDBND7 (at 0xF998C024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND7"
        group.long 0x8028--0x802B "BAM_P_CNSMR_SDBND7 (at 0xF998C028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR7"
        group.long 0x882C--0x882F "BAM_P_EVNT_DEST_ADDR7 (at 0xF998C82C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG7"
        group.long 0x8818--0x881B "BAM_P_EVNT_REG7 (at 0xF998C818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS7"
        group.long 0x8800--0x8803 "BAM_P_SW_OFSTS7 (at 0xF998C800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR7"
        group.long 0x8824--0x8827 "BAM_P_DATA_FIFO_ADDR7 (at 0xF998C824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR7"
        group.long 0x881C--0x881F "BAM_P_DESC_FIFO_ADDR7 (at 0xF998C81C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD7"
        group.long 0x8828--0x882B "BAM_P_EVNT_GEN_TRSHLD7 (at 0xF998C828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES7"
        group.long 0x8820--0x8823 "BAM_P_FIFO_SIZES7 (at 0xF998C820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_7"
        group.long 0x8834--0x8837 "BAM_P_RETR_CNTXT_7 (at 0xF998C834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_7"
        group.long 0x8838--0x883B "BAM_P_SI_CNTXT_7 (at 0xF998C838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_7"
        group.long 0x8830--0x8833 "BAM_P_DF_CNTXT_7 (at 0xF998C830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_7"
        group.long 0x8804--0x8807 "BAM_P_AU_PSM_CNTXT_1_7 (at 0xF998C804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_7"
        group.long 0x8808--0x880B "BAM_P_PSM_CNTXT_2_7 (at 0xF998C808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_7"
        group.long 0x880C--0x880F "BAM_P_PSM_CNTXT_3_7 (at 0xF998C80C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_7"
        group.long 0x8810--0x8813 "BAM_P_PSM_CNTXT_4_7 (at 0xF998C810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_7"
        group.long 0x8814--0x8817 "BAM_P_PSM_CNTXT_5_7 (at 0xF998C814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 7
tree.end
tree "Pipe 8"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL8"
        group.long 0x9000--0x9003 "BAM_P_CTRL8 (at 0xF998D000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST8"
        group.long 0x9004--0x9007 "BAM_P_RST8 (at 0xF998D004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT8"
        group.long 0x9008--0x900B "BAM_P_HALT8 (at 0xF998D008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG8"
        group.long 0x9030--0x9033 "BAM_P_TRUST_REG8 (at 0xF998D030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS8"
        group.long 0x9010--0x9013 "BAM_P_IRQ_STTS8 (at 0xF998D010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR8"
        group.long 0x9014--0x9017 "BAM_P_IRQ_CLR8 (at 0xF998D014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN8"
        group.long 0x9018--0x901B "BAM_P_IRQ_EN8 (at 0xF998D018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER8"
        group.long 0x901C--0x901F "BAM_P_TIMER8 (at 0xF998D01C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL8"
        group.long 0x9020--0x9023 "BAM_P_TIMER_CTRL8 (at 0xF998D020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND8"
        group.long 0x9024--0x9027 "BAM_P_PRDCR_SDBND8 (at 0xF998D024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND8"
        group.long 0x9028--0x902B "BAM_P_CNSMR_SDBND8 (at 0xF998D028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR8"
        group.long 0x982C--0x982F "BAM_P_EVNT_DEST_ADDR8 (at 0xF998D82C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG8"
        group.long 0x9818--0x981B "BAM_P_EVNT_REG8 (at 0xF998D818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS8"
        group.long 0x9800--0x9803 "BAM_P_SW_OFSTS8 (at 0xF998D800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR8"
        group.long 0x9824--0x9827 "BAM_P_DATA_FIFO_ADDR8 (at 0xF998D824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR8"
        group.long 0x981C--0x981F "BAM_P_DESC_FIFO_ADDR8 (at 0xF998D81C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD8"
        group.long 0x9828--0x982B "BAM_P_EVNT_GEN_TRSHLD8 (at 0xF998D828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES8"
        group.long 0x9820--0x9823 "BAM_P_FIFO_SIZES8 (at 0xF998D820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_8"
        group.long 0x9834--0x9837 "BAM_P_RETR_CNTXT_8 (at 0xF998D834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_8"
        group.long 0x9838--0x983B "BAM_P_SI_CNTXT_8 (at 0xF998D838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_8"
        group.long 0x9830--0x9833 "BAM_P_DF_CNTXT_8 (at 0xF998D830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_8"
        group.long 0x9804--0x9807 "BAM_P_AU_PSM_CNTXT_1_8 (at 0xF998D804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_8"
        group.long 0x9808--0x980B "BAM_P_PSM_CNTXT_2_8 (at 0xF998D808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_8"
        group.long 0x980C--0x980F "BAM_P_PSM_CNTXT_3_8 (at 0xF998D80C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_8"
        group.long 0x9810--0x9813 "BAM_P_PSM_CNTXT_4_8 (at 0xF998D810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_8"
        group.long 0x9814--0x9817 "BAM_P_PSM_CNTXT_5_8 (at 0xF998D814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 8
tree.end
tree "Pipe 9"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL9"
        group.long 0xA000--0xA003 "BAM_P_CTRL9 (at 0xF998E000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST9"
        group.long 0xA004--0xA007 "BAM_P_RST9 (at 0xF998E004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT9"
        group.long 0xA008--0xA00B "BAM_P_HALT9 (at 0xF998E008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG9"
        group.long 0xA030--0xA033 "BAM_P_TRUST_REG9 (at 0xF998E030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS9"
        group.long 0xA010--0xA013 "BAM_P_IRQ_STTS9 (at 0xF998E010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR9"
        group.long 0xA014--0xA017 "BAM_P_IRQ_CLR9 (at 0xF998E014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN9"
        group.long 0xA018--0xA01B "BAM_P_IRQ_EN9 (at 0xF998E018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER9"
        group.long 0xA01C--0xA01F "BAM_P_TIMER9 (at 0xF998E01C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL9"
        group.long 0xA020--0xA023 "BAM_P_TIMER_CTRL9 (at 0xF998E020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND9"
        group.long 0xA024--0xA027 "BAM_P_PRDCR_SDBND9 (at 0xF998E024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND9"
        group.long 0xA028--0xA02B "BAM_P_CNSMR_SDBND9 (at 0xF998E028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR9"
        group.long 0xA82C--0xA82F "BAM_P_EVNT_DEST_ADDR9 (at 0xF998E82C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG9"
        group.long 0xA818--0xA81B "BAM_P_EVNT_REG9 (at 0xF998E818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS9"
        group.long 0xA800--0xA803 "BAM_P_SW_OFSTS9 (at 0xF998E800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR9"
        group.long 0xA824--0xA827 "BAM_P_DATA_FIFO_ADDR9 (at 0xF998E824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR9"
        group.long 0xA81C--0xA81F "BAM_P_DESC_FIFO_ADDR9 (at 0xF998E81C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD9"
        group.long 0xA828--0xA82B "BAM_P_EVNT_GEN_TRSHLD9 (at 0xF998E828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES9"
        group.long 0xA820--0xA823 "BAM_P_FIFO_SIZES9 (at 0xF998E820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_9"
        group.long 0xA834--0xA837 "BAM_P_RETR_CNTXT_9 (at 0xF998E834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_9"
        group.long 0xA838--0xA83B "BAM_P_SI_CNTXT_9 (at 0xF998E838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_9"
        group.long 0xA830--0xA833 "BAM_P_DF_CNTXT_9 (at 0xF998E830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_9"
        group.long 0xA804--0xA807 "BAM_P_AU_PSM_CNTXT_1_9 (at 0xF998E804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_9"
        group.long 0xA808--0xA80B "BAM_P_PSM_CNTXT_2_9 (at 0xF998E808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_9"
        group.long 0xA80C--0xA80F "BAM_P_PSM_CNTXT_3_9 (at 0xF998E80C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_9"
        group.long 0xA810--0xA813 "BAM_P_PSM_CNTXT_4_9 (at 0xF998E810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_9"
        group.long 0xA814--0xA817 "BAM_P_PSM_CNTXT_5_9 (at 0xF998E814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 9
tree.end
tree "Pipe 10"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL10"
        group.long 0xB000--0xB003 "BAM_P_CTRL10 (at 0xF998F000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST10"
        group.long 0xB004--0xB007 "BAM_P_RST10 (at 0xF998F004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT10"
        group.long 0xB008--0xB00B "BAM_P_HALT10 (at 0xF998F008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG10"
        group.long 0xB030--0xB033 "BAM_P_TRUST_REG10 (at 0xF998F030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS10"
        group.long 0xB010--0xB013 "BAM_P_IRQ_STTS10 (at 0xF998F010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR10"
        group.long 0xB014--0xB017 "BAM_P_IRQ_CLR10 (at 0xF998F014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN10"
        group.long 0xB018--0xB01B "BAM_P_IRQ_EN10 (at 0xF998F018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER10"
        group.long 0xB01C--0xB01F "BAM_P_TIMER10 (at 0xF998F01C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL10"
        group.long 0xB020--0xB023 "BAM_P_TIMER_CTRL10 (at 0xF998F020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND10"
        group.long 0xB024--0xB027 "BAM_P_PRDCR_SDBND10 (at 0xF998F024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND10"
        group.long 0xB028--0xB02B "BAM_P_CNSMR_SDBND10 (at 0xF998F028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR10"
        group.long 0xB82C--0xB82F "BAM_P_EVNT_DEST_ADDR10 (at 0xF998F82C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG10"
        group.long 0xB818--0xB81B "BAM_P_EVNT_REG10 (at 0xF998F818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS10"
        group.long 0xB800--0xB803 "BAM_P_SW_OFSTS10 (at 0xF998F800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR10"
        group.long 0xB824--0xB827 "BAM_P_DATA_FIFO_ADDR10 (at 0xF998F824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR10"
        group.long 0xB81C--0xB81F "BAM_P_DESC_FIFO_ADDR10 (at 0xF998F81C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD10"
        group.long 0xB828--0xB82B "BAM_P_EVNT_GEN_TRSHLD10 (at 0xF998F828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES10"
        group.long 0xB820--0xB823 "BAM_P_FIFO_SIZES10 (at 0xF998F820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_10"
        group.long 0xB834--0xB837 "BAM_P_RETR_CNTXT_10 (at 0xF998F834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_10"
        group.long 0xB838--0xB83B "BAM_P_SI_CNTXT_10 (at 0xF998F838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_10"
        group.long 0xB830--0xB833 "BAM_P_DF_CNTXT_10 (at 0xF998F830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_10"
        group.long 0xB804--0xB807 "BAM_P_AU_PSM_CNTXT_1_10 (at 0xF998F804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_10"
        group.long 0xB808--0xB80B "BAM_P_PSM_CNTXT_2_10 (at 0xF998F808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_10"
        group.long 0xB80C--0xB80F "BAM_P_PSM_CNTXT_3_10 (at 0xF998F80C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_10"
        group.long 0xB810--0xB813 "BAM_P_PSM_CNTXT_4_10 (at 0xF998F810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_10"
        group.long 0xB814--0xB817 "BAM_P_PSM_CNTXT_5_10 (at 0xF998F814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 10
tree.end
tree "Pipe 11"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL11"
        group.long 0xC000--0xC003 "BAM_P_CTRL11 (at 0xF9990000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST11"
        group.long 0xC004--0xC007 "BAM_P_RST11 (at 0xF9990004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT11"
        group.long 0xC008--0xC00B "BAM_P_HALT11 (at 0xF9990008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG11"
        group.long 0xC030--0xC033 "BAM_P_TRUST_REG11 (at 0xF9990030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS11"
        group.long 0xC010--0xC013 "BAM_P_IRQ_STTS11 (at 0xF9990010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR11"
        group.long 0xC014--0xC017 "BAM_P_IRQ_CLR11 (at 0xF9990014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN11"
        group.long 0xC018--0xC01B "BAM_P_IRQ_EN11 (at 0xF9990018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER11"
        group.long 0xC01C--0xC01F "BAM_P_TIMER11 (at 0xF999001C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL11"
        group.long 0xC020--0xC023 "BAM_P_TIMER_CTRL11 (at 0xF9990020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND11"
        group.long 0xC024--0xC027 "BAM_P_PRDCR_SDBND11 (at 0xF9990024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND11"
        group.long 0xC028--0xC02B "BAM_P_CNSMR_SDBND11 (at 0xF9990028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR11"
        group.long 0xC82C--0xC82F "BAM_P_EVNT_DEST_ADDR11 (at 0xF999082C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG11"
        group.long 0xC818--0xC81B "BAM_P_EVNT_REG11 (at 0xF9990818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS11"
        group.long 0xC800--0xC803 "BAM_P_SW_OFSTS11 (at 0xF9990800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR11"
        group.long 0xC824--0xC827 "BAM_P_DATA_FIFO_ADDR11 (at 0xF9990824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR11"
        group.long 0xC81C--0xC81F "BAM_P_DESC_FIFO_ADDR11 (at 0xF999081C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD11"
        group.long 0xC828--0xC82B "BAM_P_EVNT_GEN_TRSHLD11 (at 0xF9990828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES11"
        group.long 0xC820--0xC823 "BAM_P_FIFO_SIZES11 (at 0xF9990820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_11"
        group.long 0xC834--0xC837 "BAM_P_RETR_CNTXT_11 (at 0xF9990834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_11"
        group.long 0xC838--0xC83B "BAM_P_SI_CNTXT_11 (at 0xF9990838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_11"
        group.long 0xC830--0xC833 "BAM_P_DF_CNTXT_11 (at 0xF9990830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_11"
        group.long 0xC804--0xC807 "BAM_P_AU_PSM_CNTXT_1_11 (at 0xF9990804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_11"
        group.long 0xC808--0xC80B "BAM_P_PSM_CNTXT_2_11 (at 0xF9990808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_11"
        group.long 0xC80C--0xC80F "BAM_P_PSM_CNTXT_3_11 (at 0xF999080C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_11"
        group.long 0xC810--0xC813 "BAM_P_PSM_CNTXT_4_11 (at 0xF9990810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_11"
        group.long 0xC814--0xC817 "BAM_P_PSM_CNTXT_5_11 (at 0xF9990814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 11
tree.end
tree "Pipe 12"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL12"
        group.long 0xD000--0xD003 "BAM_P_CTRL12 (at 0xF9991000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST12"
        group.long 0xD004--0xD007 "BAM_P_RST12 (at 0xF9991004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT12"
        group.long 0xD008--0xD00B "BAM_P_HALT12 (at 0xF9991008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG12"
        group.long 0xD030--0xD033 "BAM_P_TRUST_REG12 (at 0xF9991030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS12"
        group.long 0xD010--0xD013 "BAM_P_IRQ_STTS12 (at 0xF9991010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR12"
        group.long 0xD014--0xD017 "BAM_P_IRQ_CLR12 (at 0xF9991014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN12"
        group.long 0xD018--0xD01B "BAM_P_IRQ_EN12 (at 0xF9991018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER12"
        group.long 0xD01C--0xD01F "BAM_P_TIMER12 (at 0xF999101C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL12"
        group.long 0xD020--0xD023 "BAM_P_TIMER_CTRL12 (at 0xF9991020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND12"
        group.long 0xD024--0xD027 "BAM_P_PRDCR_SDBND12 (at 0xF9991024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND12"
        group.long 0xD028--0xD02B "BAM_P_CNSMR_SDBND12 (at 0xF9991028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR12"
        group.long 0xD82C--0xD82F "BAM_P_EVNT_DEST_ADDR12 (at 0xF999182C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG12"
        group.long 0xD818--0xD81B "BAM_P_EVNT_REG12 (at 0xF9991818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS12"
        group.long 0xD800--0xD803 "BAM_P_SW_OFSTS12 (at 0xF9991800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR12"
        group.long 0xD824--0xD827 "BAM_P_DATA_FIFO_ADDR12 (at 0xF9991824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR12"
        group.long 0xD81C--0xD81F "BAM_P_DESC_FIFO_ADDR12 (at 0xF999181C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD12"
        group.long 0xD828--0xD82B "BAM_P_EVNT_GEN_TRSHLD12 (at 0xF9991828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES12"
        group.long 0xD820--0xD823 "BAM_P_FIFO_SIZES12 (at 0xF9991820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_12"
        group.long 0xD834--0xD837 "BAM_P_RETR_CNTXT_12 (at 0xF9991834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_12"
        group.long 0xD838--0xD83B "BAM_P_SI_CNTXT_12 (at 0xF9991838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_12"
        group.long 0xD830--0xD833 "BAM_P_DF_CNTXT_12 (at 0xF9991830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_12"
        group.long 0xD804--0xD807 "BAM_P_AU_PSM_CNTXT_1_12 (at 0xF9991804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_12"
        group.long 0xD808--0xD80B "BAM_P_PSM_CNTXT_2_12 (at 0xF9991808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_12"
        group.long 0xD80C--0xD80F "BAM_P_PSM_CNTXT_3_12 (at 0xF999180C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_12"
        group.long 0xD810--0xD813 "BAM_P_PSM_CNTXT_4_12 (at 0xF9991810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_12"
        group.long 0xD814--0xD817 "BAM_P_PSM_CNTXT_5_12 (at 0xF9991814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 12
tree.end
tree "Pipe 13"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL13"
        group.long 0xE000--0xE003 "BAM_P_CTRL13 (at 0xF9992000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST13"
        group.long 0xE004--0xE007 "BAM_P_RST13 (at 0xF9992004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT13"
        group.long 0xE008--0xE00B "BAM_P_HALT13 (at 0xF9992008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG13"
        group.long 0xE030--0xE033 "BAM_P_TRUST_REG13 (at 0xF9992030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS13"
        group.long 0xE010--0xE013 "BAM_P_IRQ_STTS13 (at 0xF9992010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR13"
        group.long 0xE014--0xE017 "BAM_P_IRQ_CLR13 (at 0xF9992014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN13"
        group.long 0xE018--0xE01B "BAM_P_IRQ_EN13 (at 0xF9992018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER13"
        group.long 0xE01C--0xE01F "BAM_P_TIMER13 (at 0xF999201C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL13"
        group.long 0xE020--0xE023 "BAM_P_TIMER_CTRL13 (at 0xF9992020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND13"
        group.long 0xE024--0xE027 "BAM_P_PRDCR_SDBND13 (at 0xF9992024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND13"
        group.long 0xE028--0xE02B "BAM_P_CNSMR_SDBND13 (at 0xF9992028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR13"
        group.long 0xE82C--0xE82F "BAM_P_EVNT_DEST_ADDR13 (at 0xF999282C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG13"
        group.long 0xE818--0xE81B "BAM_P_EVNT_REG13 (at 0xF9992818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS13"
        group.long 0xE800--0xE803 "BAM_P_SW_OFSTS13 (at 0xF9992800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR13"
        group.long 0xE824--0xE827 "BAM_P_DATA_FIFO_ADDR13 (at 0xF9992824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR13"
        group.long 0xE81C--0xE81F "BAM_P_DESC_FIFO_ADDR13 (at 0xF999281C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD13"
        group.long 0xE828--0xE82B "BAM_P_EVNT_GEN_TRSHLD13 (at 0xF9992828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES13"
        group.long 0xE820--0xE823 "BAM_P_FIFO_SIZES13 (at 0xF9992820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_13"
        group.long 0xE834--0xE837 "BAM_P_RETR_CNTXT_13 (at 0xF9992834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_13"
        group.long 0xE838--0xE83B "BAM_P_SI_CNTXT_13 (at 0xF9992838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_13"
        group.long 0xE830--0xE833 "BAM_P_DF_CNTXT_13 (at 0xF9992830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_13"
        group.long 0xE804--0xE807 "BAM_P_AU_PSM_CNTXT_1_13 (at 0xF9992804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_13"
        group.long 0xE808--0xE80B "BAM_P_PSM_CNTXT_2_13 (at 0xF9992808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_13"
        group.long 0xE80C--0xE80F "BAM_P_PSM_CNTXT_3_13 (at 0xF999280C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_13"
        group.long 0xE810--0xE813 "BAM_P_PSM_CNTXT_4_13 (at 0xF9992810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_13"
        group.long 0xE814--0xE817 "BAM_P_PSM_CNTXT_5_13 (at 0xF9992814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 13
tree.end
tree "Pipe 14"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL14"
        group.long 0xF000--0xF003 "BAM_P_CTRL14 (at 0xF9993000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST14"
        group.long 0xF004--0xF007 "BAM_P_RST14 (at 0xF9993004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT14"
        group.long 0xF008--0xF00B "BAM_P_HALT14 (at 0xF9993008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG14"
        group.long 0xF030--0xF033 "BAM_P_TRUST_REG14 (at 0xF9993030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS14"
        group.long 0xF010--0xF013 "BAM_P_IRQ_STTS14 (at 0xF9993010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR14"
        group.long 0xF014--0xF017 "BAM_P_IRQ_CLR14 (at 0xF9993014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN14"
        group.long 0xF018--0xF01B "BAM_P_IRQ_EN14 (at 0xF9993018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER14"
        group.long 0xF01C--0xF01F "BAM_P_TIMER14 (at 0xF999301C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL14"
        group.long 0xF020--0xF023 "BAM_P_TIMER_CTRL14 (at 0xF9993020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND14"
        group.long 0xF024--0xF027 "BAM_P_PRDCR_SDBND14 (at 0xF9993024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND14"
        group.long 0xF028--0xF02B "BAM_P_CNSMR_SDBND14 (at 0xF9993028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR14"
        group.long 0xF82C--0xF82F "BAM_P_EVNT_DEST_ADDR14 (at 0xF999382C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG14"
        group.long 0xF818--0xF81B "BAM_P_EVNT_REG14 (at 0xF9993818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS14"
        group.long 0xF800--0xF803 "BAM_P_SW_OFSTS14 (at 0xF9993800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR14"
        group.long 0xF824--0xF827 "BAM_P_DATA_FIFO_ADDR14 (at 0xF9993824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR14"
        group.long 0xF81C--0xF81F "BAM_P_DESC_FIFO_ADDR14 (at 0xF999381C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD14"
        group.long 0xF828--0xF82B "BAM_P_EVNT_GEN_TRSHLD14 (at 0xF9993828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES14"
        group.long 0xF820--0xF823 "BAM_P_FIFO_SIZES14 (at 0xF9993820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_14"
        group.long 0xF834--0xF837 "BAM_P_RETR_CNTXT_14 (at 0xF9993834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_14"
        group.long 0xF838--0xF83B "BAM_P_SI_CNTXT_14 (at 0xF9993838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_14"
        group.long 0xF830--0xF833 "BAM_P_DF_CNTXT_14 (at 0xF9993830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_14"
        group.long 0xF804--0xF807 "BAM_P_AU_PSM_CNTXT_1_14 (at 0xF9993804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_14"
        group.long 0xF808--0xF80B "BAM_P_PSM_CNTXT_2_14 (at 0xF9993808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_14"
        group.long 0xF80C--0xF80F "BAM_P_PSM_CNTXT_3_14 (at 0xF999380C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_14"
        group.long 0xF810--0xF813 "BAM_P_PSM_CNTXT_4_14 (at 0xF9993810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_14"
        group.long 0xF814--0xF817 "BAM_P_PSM_CNTXT_5_14 (at 0xF9993814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 14
tree.end
tree "Pipe 15"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL15"
        group.long 0x10000--0x10003 "BAM_P_CTRL15 (at 0xF9994000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST15"
        group.long 0x10004--0x10007 "BAM_P_RST15 (at 0xF9994004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT15"
        group.long 0x10008--0x1000B "BAM_P_HALT15 (at 0xF9994008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG15"
        group.long 0x10030--0x10033 "BAM_P_TRUST_REG15 (at 0xF9994030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS15"
        group.long 0x10010--0x10013 "BAM_P_IRQ_STTS15 (at 0xF9994010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR15"
        group.long 0x10014--0x10017 "BAM_P_IRQ_CLR15 (at 0xF9994014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN15"
        group.long 0x10018--0x1001B "BAM_P_IRQ_EN15 (at 0xF9994018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER15"
        group.long 0x1001C--0x1001F "BAM_P_TIMER15 (at 0xF999401C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL15"
        group.long 0x10020--0x10023 "BAM_P_TIMER_CTRL15 (at 0xF9994020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND15"
        group.long 0x10024--0x10027 "BAM_P_PRDCR_SDBND15 (at 0xF9994024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND15"
        group.long 0x10028--0x1002B "BAM_P_CNSMR_SDBND15 (at 0xF9994028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR15"
        group.long 0x1082C--0x1082F "BAM_P_EVNT_DEST_ADDR15 (at 0xF999482C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG15"
        group.long 0x10818--0x1081B "BAM_P_EVNT_REG15 (at 0xF9994818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS15"
        group.long 0x10800--0x10803 "BAM_P_SW_OFSTS15 (at 0xF9994800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR15"
        group.long 0x10824--0x10827 "BAM_P_DATA_FIFO_ADDR15 (at 0xF9994824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR15"
        group.long 0x1081C--0x1081F "BAM_P_DESC_FIFO_ADDR15 (at 0xF999481C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD15"
        group.long 0x10828--0x1082B "BAM_P_EVNT_GEN_TRSHLD15 (at 0xF9994828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES15"
        group.long 0x10820--0x10823 "BAM_P_FIFO_SIZES15 (at 0xF9994820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_15"
        group.long 0x10834--0x10837 "BAM_P_RETR_CNTXT_15 (at 0xF9994834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_15"
        group.long 0x10838--0x1083B "BAM_P_SI_CNTXT_15 (at 0xF9994838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_15"
        group.long 0x10830--0x10833 "BAM_P_DF_CNTXT_15 (at 0xF9994830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_15"
        group.long 0x10804--0x10807 "BAM_P_AU_PSM_CNTXT_1_15 (at 0xF9994804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_15"
        group.long 0x10808--0x1080B "BAM_P_PSM_CNTXT_2_15 (at 0xF9994808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_15"
        group.long 0x1080C--0x1080F "BAM_P_PSM_CNTXT_3_15 (at 0xF999480C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_15"
        group.long 0x10810--0x10813 "BAM_P_PSM_CNTXT_4_15 (at 0xF9994810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_15"
        group.long 0x10814--0x10817 "BAM_P_PSM_CNTXT_5_15 (at 0xF9994814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 15
tree.end
tree "Pipe 16"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL16"
        group.long 0x11000--0x11003 "BAM_P_CTRL16 (at 0xF9995000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST16"
        group.long 0x11004--0x11007 "BAM_P_RST16 (at 0xF9995004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT16"
        group.long 0x11008--0x1100B "BAM_P_HALT16 (at 0xF9995008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG16"
        group.long 0x11030--0x11033 "BAM_P_TRUST_REG16 (at 0xF9995030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS16"
        group.long 0x11010--0x11013 "BAM_P_IRQ_STTS16 (at 0xF9995010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR16"
        group.long 0x11014--0x11017 "BAM_P_IRQ_CLR16 (at 0xF9995014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN16"
        group.long 0x11018--0x1101B "BAM_P_IRQ_EN16 (at 0xF9995018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER16"
        group.long 0x1101C--0x1101F "BAM_P_TIMER16 (at 0xF999501C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL16"
        group.long 0x11020--0x11023 "BAM_P_TIMER_CTRL16 (at 0xF9995020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND16"
        group.long 0x11024--0x11027 "BAM_P_PRDCR_SDBND16 (at 0xF9995024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND16"
        group.long 0x11028--0x1102B "BAM_P_CNSMR_SDBND16 (at 0xF9995028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR16"
        group.long 0x1182C--0x1182F "BAM_P_EVNT_DEST_ADDR16 (at 0xF999582C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG16"
        group.long 0x11818--0x1181B "BAM_P_EVNT_REG16 (at 0xF9995818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS16"
        group.long 0x11800--0x11803 "BAM_P_SW_OFSTS16 (at 0xF9995800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR16"
        group.long 0x11824--0x11827 "BAM_P_DATA_FIFO_ADDR16 (at 0xF9995824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR16"
        group.long 0x1181C--0x1181F "BAM_P_DESC_FIFO_ADDR16 (at 0xF999581C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD16"
        group.long 0x11828--0x1182B "BAM_P_EVNT_GEN_TRSHLD16 (at 0xF9995828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES16"
        group.long 0x11820--0x11823 "BAM_P_FIFO_SIZES16 (at 0xF9995820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_16"
        group.long 0x11834--0x11837 "BAM_P_RETR_CNTXT_16 (at 0xF9995834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_16"
        group.long 0x11838--0x1183B "BAM_P_SI_CNTXT_16 (at 0xF9995838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_16"
        group.long 0x11830--0x11833 "BAM_P_DF_CNTXT_16 (at 0xF9995830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_16"
        group.long 0x11804--0x11807 "BAM_P_AU_PSM_CNTXT_1_16 (at 0xF9995804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_16"
        group.long 0x11808--0x1180B "BAM_P_PSM_CNTXT_2_16 (at 0xF9995808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_16"
        group.long 0x1180C--0x1180F "BAM_P_PSM_CNTXT_3_16 (at 0xF999580C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_16"
        group.long 0x11810--0x11813 "BAM_P_PSM_CNTXT_4_16 (at 0xF9995810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_16"
        group.long 0x11814--0x11817 "BAM_P_PSM_CNTXT_5_16 (at 0xF9995814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 16
tree.end
tree "Pipe 17"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL17"
        group.long 0x12000--0x12003 "BAM_P_CTRL17 (at 0xF9996000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST17"
        group.long 0x12004--0x12007 "BAM_P_RST17 (at 0xF9996004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT17"
        group.long 0x12008--0x1200B "BAM_P_HALT17 (at 0xF9996008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG17"
        group.long 0x12030--0x12033 "BAM_P_TRUST_REG17 (at 0xF9996030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS17"
        group.long 0x12010--0x12013 "BAM_P_IRQ_STTS17 (at 0xF9996010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR17"
        group.long 0x12014--0x12017 "BAM_P_IRQ_CLR17 (at 0xF9996014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN17"
        group.long 0x12018--0x1201B "BAM_P_IRQ_EN17 (at 0xF9996018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER17"
        group.long 0x1201C--0x1201F "BAM_P_TIMER17 (at 0xF999601C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL17"
        group.long 0x12020--0x12023 "BAM_P_TIMER_CTRL17 (at 0xF9996020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND17"
        group.long 0x12024--0x12027 "BAM_P_PRDCR_SDBND17 (at 0xF9996024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND17"
        group.long 0x12028--0x1202B "BAM_P_CNSMR_SDBND17 (at 0xF9996028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR17"
        group.long 0x1282C--0x1282F "BAM_P_EVNT_DEST_ADDR17 (at 0xF999682C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG17"
        group.long 0x12818--0x1281B "BAM_P_EVNT_REG17 (at 0xF9996818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS17"
        group.long 0x12800--0x12803 "BAM_P_SW_OFSTS17 (at 0xF9996800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR17"
        group.long 0x12824--0x12827 "BAM_P_DATA_FIFO_ADDR17 (at 0xF9996824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR17"
        group.long 0x1281C--0x1281F "BAM_P_DESC_FIFO_ADDR17 (at 0xF999681C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD17"
        group.long 0x12828--0x1282B "BAM_P_EVNT_GEN_TRSHLD17 (at 0xF9996828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES17"
        group.long 0x12820--0x12823 "BAM_P_FIFO_SIZES17 (at 0xF9996820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_17"
        group.long 0x12834--0x12837 "BAM_P_RETR_CNTXT_17 (at 0xF9996834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_17"
        group.long 0x12838--0x1283B "BAM_P_SI_CNTXT_17 (at 0xF9996838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_17"
        group.long 0x12830--0x12833 "BAM_P_DF_CNTXT_17 (at 0xF9996830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_17"
        group.long 0x12804--0x12807 "BAM_P_AU_PSM_CNTXT_1_17 (at 0xF9996804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_17"
        group.long 0x12808--0x1280B "BAM_P_PSM_CNTXT_2_17 (at 0xF9996808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_17"
        group.long 0x1280C--0x1280F "BAM_P_PSM_CNTXT_3_17 (at 0xF999680C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_17"
        group.long 0x12810--0x12813 "BAM_P_PSM_CNTXT_4_17 (at 0xF9996810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_17"
        group.long 0x12814--0x12817 "BAM_P_PSM_CNTXT_5_17 (at 0xF9996814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 17
tree.end
tree "Pipe 18"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL18"
        group.long 0x13000--0x13003 "BAM_P_CTRL18 (at 0xF9997000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST18"
        group.long 0x13004--0x13007 "BAM_P_RST18 (at 0xF9997004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT18"
        group.long 0x13008--0x1300B "BAM_P_HALT18 (at 0xF9997008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG18"
        group.long 0x13030--0x13033 "BAM_P_TRUST_REG18 (at 0xF9997030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS18"
        group.long 0x13010--0x13013 "BAM_P_IRQ_STTS18 (at 0xF9997010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR18"
        group.long 0x13014--0x13017 "BAM_P_IRQ_CLR18 (at 0xF9997014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN18"
        group.long 0x13018--0x1301B "BAM_P_IRQ_EN18 (at 0xF9997018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER18"
        group.long 0x1301C--0x1301F "BAM_P_TIMER18 (at 0xF999701C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL18"
        group.long 0x13020--0x13023 "BAM_P_TIMER_CTRL18 (at 0xF9997020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND18"
        group.long 0x13024--0x13027 "BAM_P_PRDCR_SDBND18 (at 0xF9997024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND18"
        group.long 0x13028--0x1302B "BAM_P_CNSMR_SDBND18 (at 0xF9997028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR18"
        group.long 0x1382C--0x1382F "BAM_P_EVNT_DEST_ADDR18 (at 0xF999782C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG18"
        group.long 0x13818--0x1381B "BAM_P_EVNT_REG18 (at 0xF9997818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS18"
        group.long 0x13800--0x13803 "BAM_P_SW_OFSTS18 (at 0xF9997800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR18"
        group.long 0x13824--0x13827 "BAM_P_DATA_FIFO_ADDR18 (at 0xF9997824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR18"
        group.long 0x1381C--0x1381F "BAM_P_DESC_FIFO_ADDR18 (at 0xF999781C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD18"
        group.long 0x13828--0x1382B "BAM_P_EVNT_GEN_TRSHLD18 (at 0xF9997828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES18"
        group.long 0x13820--0x13823 "BAM_P_FIFO_SIZES18 (at 0xF9997820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_18"
        group.long 0x13834--0x13837 "BAM_P_RETR_CNTXT_18 (at 0xF9997834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_18"
        group.long 0x13838--0x1383B "BAM_P_SI_CNTXT_18 (at 0xF9997838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_18"
        group.long 0x13830--0x13833 "BAM_P_DF_CNTXT_18 (at 0xF9997830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_18"
        group.long 0x13804--0x13807 "BAM_P_AU_PSM_CNTXT_1_18 (at 0xF9997804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_18"
        group.long 0x13808--0x1380B "BAM_P_PSM_CNTXT_2_18 (at 0xF9997808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_18"
        group.long 0x1380C--0x1380F "BAM_P_PSM_CNTXT_3_18 (at 0xF999780C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_18"
        group.long 0x13810--0x13813 "BAM_P_PSM_CNTXT_4_18 (at 0xF9997810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_18"
        group.long 0x13814--0x13817 "BAM_P_PSM_CNTXT_5_18 (at 0xF9997814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 18
tree.end
tree "Pipe 19"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL19"
        group.long 0x14000--0x14003 "BAM_P_CTRL19 (at 0xF9998000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST19"
        group.long 0x14004--0x14007 "BAM_P_RST19 (at 0xF9998004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT19"
        group.long 0x14008--0x1400B "BAM_P_HALT19 (at 0xF9998008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG19"
        group.long 0x14030--0x14033 "BAM_P_TRUST_REG19 (at 0xF9998030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS19"
        group.long 0x14010--0x14013 "BAM_P_IRQ_STTS19 (at 0xF9998010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR19"
        group.long 0x14014--0x14017 "BAM_P_IRQ_CLR19 (at 0xF9998014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN19"
        group.long 0x14018--0x1401B "BAM_P_IRQ_EN19 (at 0xF9998018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER19"
        group.long 0x1401C--0x1401F "BAM_P_TIMER19 (at 0xF999801C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL19"
        group.long 0x14020--0x14023 "BAM_P_TIMER_CTRL19 (at 0xF9998020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND19"
        group.long 0x14024--0x14027 "BAM_P_PRDCR_SDBND19 (at 0xF9998024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND19"
        group.long 0x14028--0x1402B "BAM_P_CNSMR_SDBND19 (at 0xF9998028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR19"
        group.long 0x1482C--0x1482F "BAM_P_EVNT_DEST_ADDR19 (at 0xF999882C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG19"
        group.long 0x14818--0x1481B "BAM_P_EVNT_REG19 (at 0xF9998818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS19"
        group.long 0x14800--0x14803 "BAM_P_SW_OFSTS19 (at 0xF9998800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR19"
        group.long 0x14824--0x14827 "BAM_P_DATA_FIFO_ADDR19 (at 0xF9998824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR19"
        group.long 0x1481C--0x1481F "BAM_P_DESC_FIFO_ADDR19 (at 0xF999881C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD19"
        group.long 0x14828--0x1482B "BAM_P_EVNT_GEN_TRSHLD19 (at 0xF9998828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES19"
        group.long 0x14820--0x14823 "BAM_P_FIFO_SIZES19 (at 0xF9998820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_19"
        group.long 0x14834--0x14837 "BAM_P_RETR_CNTXT_19 (at 0xF9998834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_19"
        group.long 0x14838--0x1483B "BAM_P_SI_CNTXT_19 (at 0xF9998838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_19"
        group.long 0x14830--0x14833 "BAM_P_DF_CNTXT_19 (at 0xF9998830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_19"
        group.long 0x14804--0x14807 "BAM_P_AU_PSM_CNTXT_1_19 (at 0xF9998804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_19"
        group.long 0x14808--0x1480B "BAM_P_PSM_CNTXT_2_19 (at 0xF9998808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_19"
        group.long 0x1480C--0x1480F "BAM_P_PSM_CNTXT_3_19 (at 0xF999880C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_19"
        group.long 0x14810--0x14813 "BAM_P_PSM_CNTXT_4_19 (at 0xF9998810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_19"
        group.long 0x14814--0x14817 "BAM_P_PSM_CNTXT_5_19 (at 0xF9998814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 19
tree.end
tree.end
;Block Per Data Ends

base ad:0xF9999000
tree "BAMDMA"
      tree "DMA_ENBL"
        group.long 0x0--0x3 "DMA_ENBL (at 0xF9999000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   DMA_ENABLE                               = "  "0,1"
        textline ""
      tree.end
      tree "DMA_CHNL_CONFIG0"
        group.long 0x1000--0x1003 "DMA_CHNL_CONFIG0 (at 0xF999A000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x12 " [   18]   PRODUCER_PIPE_ENABLED                    = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11 " [   17]   CONSUMER_PIPE_ENABLED                    = "  "0,1"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   DMA_CHNL_HALT_DONE                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0xC " [   12]   DMA_CHNL_HALT                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x8 " [   08]   DMA_CHNL_ENABLE                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4--0x5 " [05:04]   DMA_CHNL_ACT_THRESH                      = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   DMA_CHNL_WEIGHT                          = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "DMA_CHNL_CONFIG1"
        group.long 0x2000--0x2003 "DMA_CHNL_CONFIG1 (at 0xF999B000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x12 " [   18]   PRODUCER_PIPE_ENABLED                    = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11 " [   17]   CONSUMER_PIPE_ENABLED                    = "  "0,1"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   DMA_CHNL_HALT_DONE                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0xC " [   12]   DMA_CHNL_HALT                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x8 " [   08]   DMA_CHNL_ENABLE                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4--0x5 " [05:04]   DMA_CHNL_ACT_THRESH                      = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   DMA_CHNL_WEIGHT                          = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "DMA_CHNL_CONFIG2"
        group.long 0x3000--0x3003 "DMA_CHNL_CONFIG2 (at 0xF999C000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x12 " [   18]   PRODUCER_PIPE_ENABLED                    = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11 " [   17]   CONSUMER_PIPE_ENABLED                    = "  "0,1"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   DMA_CHNL_HALT_DONE                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0xC " [   12]   DMA_CHNL_HALT                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x8 " [   08]   DMA_CHNL_ENABLE                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4--0x5 " [05:04]   DMA_CHNL_ACT_THRESH                      = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   DMA_CHNL_WEIGHT                          = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "DMA_CHNL_CONFIG3"
        group.long 0x4000--0x4003 "DMA_CHNL_CONFIG3 (at 0xF999D000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x12 " [   18]   PRODUCER_PIPE_ENABLED                    = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11 " [   17]   CONSUMER_PIPE_ENABLED                    = "  "0,1"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   DMA_CHNL_HALT_DONE                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0xC " [   12]   DMA_CHNL_HALT                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x8 " [   08]   DMA_CHNL_ENABLE                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4--0x5 " [05:04]   DMA_CHNL_ACT_THRESH                      = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   DMA_CHNL_WEIGHT                          = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "DMA_CHNL_CONFIG4"
        group.long 0x5000--0x5003 "DMA_CHNL_CONFIG4 (at 0xF999E000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x12 " [   18]   PRODUCER_PIPE_ENABLED                    = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11 " [   17]   CONSUMER_PIPE_ENABLED                    = "  "0,1"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   DMA_CHNL_HALT_DONE                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0xC " [   12]   DMA_CHNL_HALT                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x8 " [   08]   DMA_CHNL_ENABLE                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4--0x5 " [05:04]   DMA_CHNL_ACT_THRESH                      = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   DMA_CHNL_WEIGHT                          = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "DMA_CHNL_CONFIG5"
        group.long 0x6000--0x6003 "DMA_CHNL_CONFIG5 (at 0xF999F000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x12 " [   18]   PRODUCER_PIPE_ENABLED                    = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11 " [   17]   CONSUMER_PIPE_ENABLED                    = "  "0,1"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   DMA_CHNL_HALT_DONE                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0xC " [   12]   DMA_CHNL_HALT                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x8 " [   08]   DMA_CHNL_ENABLE                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4--0x5 " [05:04]   DMA_CHNL_ACT_THRESH                      = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   DMA_CHNL_WEIGHT                          = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "DMA_CHNL_CONFIG6"
        group.long 0x7000--0x7003 "DMA_CHNL_CONFIG6 (at 0xF99A0000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x12 " [   18]   PRODUCER_PIPE_ENABLED                    = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11 " [   17]   CONSUMER_PIPE_ENABLED                    = "  "0,1"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   DMA_CHNL_HALT_DONE                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0xC " [   12]   DMA_CHNL_HALT                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x8 " [   08]   DMA_CHNL_ENABLE                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4--0x5 " [05:04]   DMA_CHNL_ACT_THRESH                      = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   DMA_CHNL_WEIGHT                          = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "DMA_CHNL_CONFIG7"
        group.long 0x8000--0x8003 "DMA_CHNL_CONFIG7 (at 0xF99A1000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x12 " [   18]   PRODUCER_PIPE_ENABLED                    = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11 " [   17]   CONSUMER_PIPE_ENABLED                    = "  "0,1"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   DMA_CHNL_HALT_DONE                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0xC " [   12]   DMA_CHNL_HALT                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x8 " [   08]   DMA_CHNL_ENABLE                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4--0x5 " [05:04]   DMA_CHNL_ACT_THRESH                      = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   DMA_CHNL_WEIGHT                          = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "DMA_CHNL_CONFIG8"
        group.long 0x9000--0x9003 "DMA_CHNL_CONFIG8 (at 0xF99A2000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x12 " [   18]   PRODUCER_PIPE_ENABLED                    = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11 " [   17]   CONSUMER_PIPE_ENABLED                    = "  "0,1"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   DMA_CHNL_HALT_DONE                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0xC " [   12]   DMA_CHNL_HALT                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x8 " [   08]   DMA_CHNL_ENABLE                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4--0x5 " [05:04]   DMA_CHNL_ACT_THRESH                      = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   DMA_CHNL_WEIGHT                          = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "DMA_CHNL_CONFIG9"
        group.long 0xA000--0xA003 "DMA_CHNL_CONFIG9 (at 0xF99A3000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x12 " [   18]   PRODUCER_PIPE_ENABLED                    = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11 " [   17]   CONSUMER_PIPE_ENABLED                    = "  "0,1"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   DMA_CHNL_HALT_DONE                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0xC " [   12]   DMA_CHNL_HALT                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x8 " [   08]   DMA_CHNL_ENABLE                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4--0x5 " [05:04]   DMA_CHNL_ACT_THRESH                      = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   DMA_CHNL_WEIGHT                          = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "DMA_REVISION"
        group.long 0x4--0x7 "DMA_REVISION (at 0xF9999004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   REVISION                                 = " 
        textline ""
      tree.end
      tree "DMA_CONFIG"
        group.long 0x8--0xB "DMA_CONFIG (at 0xF9999008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0--0x1 " [01:00]   TESTBUS_SELECT                           = "  "2 (BAM_TESTBUS_IS_SELECTED),3 (ALL_BITS_ARE_ZERO)"
        textline ""
      tree.end
tree.end
;Block Per Data Ends

base ad:0xF99C4000
tree "TSIF"
tree "BAM Control Registers"
      tree "BAM_CTRL"
        group.long 0x0--0x3 "BAM_CTRL (at 0xF99C4000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x13 " [   19]   CACHE_MISS_ERR_RESP_EN                   = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11--0x12 " [18:17]   LOCAL_CLK_GATING                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   IBC_DISABLE                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0xF " [   15]   BAM_CACHED_DESC_STORE                    = "  "0,1"
        textline ""
        bitfld.long 0x0 0xD--0xE " [14:13]   BAM_DESC_CACHE_SEL                       = "  "0,1,2,3"
        textline ""
        hexmask.long.word 0x0 0x5--0xB 1  " [11:05]   BAM_TESTBUS_SEL                          = " 
        textline ""
        bitfld.long 0x0 0x4 " [   04]   BAM_EN_ACCUM                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_EN                                   = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   BAM_SW_RST                               = "  "0,1"
        textline ""
      tree.end
      tree "BAM_REVISION"
        group.long 0x4--0x7 "BAM_REVISION (at 0xF99C4004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x18--0x1F 1  " [31:24]   INACTIV_TMR_BASE                         = " 
        textline ""
        bitfld.long 0x0 0x17 " [   23]   CMD_DESC_EN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15--0x16 " [22:21]   DESC_CACHE_DEPTH                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   NUM_INACTIV_TMRS                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x13 " [   19]   INACTIV_TMRS_EXST                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x12 " [   18]   HIGH_FREQUENCY_BAM                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11 " [   17]   BAM_HAS_NO_BYPASS                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   SECURED                                  = "  "0,1"
        textline ""
        bitfld.long 0x0 0xF " [   15]   USE_VMIDMT                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0xE " [   14]   AXI_ACTIVE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0xD " [   13]   CE_BUFFER_SIZE                           = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x8--0xB 1  " [11:08]   NUM_EES                                  = " 
        textline ""
        hexmask.long.word 0x0 0x0--0x7 1  " [07:00]   REVISION                                 = " 
        textline ""
      tree.end
      tree "BAM_SW_VERSION"
        group.long 0x80--0x83 "BAM_SW_VERSION (at 0xF99C4080) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x1C--0x1F 1  " [31:28]   MAJOR                                    = " 
        textline ""
        hexmask.long.word 0x0 0x10--0x1B 1  " [27:16]   MINOR                                    = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   STEP                                     = " 
        textline ""
      tree.end
      tree "BAM_NUM_PIPES"
        group.long 0x3C--0x3F "BAM_NUM_PIPES (at 0xF99C403C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x18--0x1F 1  " [31:24]   BAM_NON_PIPE_GRP                         = " 
        textline ""
        hexmask.long.word 0x0 0x10--0x17 1  " [23:16]   PERIPH_NON_PIPE_GRP                      = " 
        textline ""
        hexmask.long.word 0x0 0x0--0x7 1  " [07:00]   BAM_NUM_PIPES                            = " 
        textline ""
      tree.end
      tree "BAM_TIMER"
        group.long 0x40--0x43 "BAM_TIMER (at 0xF99C4040) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   TIMER                                    = " 
        textline ""
      tree.end
      tree "BAM_TIMER_CTRL"
        group.long 0x44--0x47 "BAM_TIMER_CTRL (at 0xF99C4044) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   TIMER_RST                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   TIMER_RUN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   TIMER_MODE                               = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   TIMER_TRSHLD                             = " 
        textline ""
      tree.end
      tree "BAM_DESC_CNT_TRSHLD"
        group.long 0x8--0xB "BAM_DESC_CNT_TRSHLD (at 0xF99C4008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   CNT_TRSHLD                               = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS"
        group.long 0xC--0xF "BAM_IRQ_SRCS (at 0xF99C400C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK"
        group.long 0x10--0x13 "BAM_IRQ_SRCS_MSK (at 0xF99C4010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED"
        group.long 0x30--0x33 "BAM_IRQ_SRCS_UNMASKED (at 0xF99C4030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_STTS"
        group.long 0x14--0x17 "BAM_IRQ_STTS (at 0xF99C4014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x4 " [   04]   BAM_TIMER_IRQ                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   BAM_EMPTY_IRQ                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_ERROR_IRQ                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_HRESP_ERR_IRQ                        = "  "0,1"
        textline ""
      tree.end
      tree "BAM_IRQ_CLR"
        group.long 0x18--0x1B "BAM_IRQ_CLR (at 0xF99C4018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x4 " [   04]   BAM_TIMER_CLR                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   BAM_EMPTY_CLR                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_ERROR_CLR                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_HRESP_ERR_CLR                        = "  "0,1"
        textline ""
      tree.end
      tree "BAM_IRQ_EN"
        group.long 0x1C--0x1F "BAM_IRQ_EN (at 0xF99C401C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x4 " [   04]   BAM_TIMER_EN                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   BAM_EMPTY_EN                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_ERROR_EN                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_HRESP_ERR_EN                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_AHB_MASTER_ERR_CTRLS"
        group.long 0x24--0x27 "BAM_AHB_MASTER_ERR_CTRLS (at 0xF99C4024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x12--0x16 1  " [22:18]   BAM_ERR_HVMID                            = " 
        textline ""
        bitfld.long 0x0 0x11 " [   17]   BAM_ERR_DIRECT_MODE                      = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0xC--0x10 1  " [16:12]   BAM_ERR_HCID                             = " 
        textline ""
        hexmask.long.word 0x0 0x8--0xB 1  " [11:08]   BAM_ERR_HPROT                            = " 
        textline ""
        bitfld.long 0x0 0x5--0x7 " [07:05]   BAM_ERR_HBURST                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x3--0x4 " [04:03]   BAM_ERR_HSIZE                            = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_ERR_HWRITE                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0--0x1 " [01:00]   BAM_ERR_HTRANS                           = "  "0,1,2,3"
        textline ""
      tree.end
      tree "BAM_AHB_MASTER_ERR_ADDR"
        group.long 0x28--0x2B "BAM_AHB_MASTER_ERR_ADDR (at 0xF99C4028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   BAM_ERR_ADDR                             = " 
        textline ""
      tree.end
      tree "BAM_AHB_MASTER_ERR_DATA"
        group.long 0x2C--0x2F "BAM_AHB_MASTER_ERR_DATA (at 0xF99C402C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   BAM_ERR_DATA                             = " 
        textline ""
      tree.end
      tree "BAM_TRUST_REG"
        group.long 0x70--0x73 "BAM_TRUST_REG (at 0xF99C4070) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0xD " [   13]   LOCK_EE_CTRL                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_VMID                                 = " 
        textline ""
        bitfld.long 0x0 0x7 " [   07]   BAM_RST_BLOCK                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_EE                                   = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_TEST_BUS_SEL"
        group.long 0x74--0x77 "BAM_TEST_BUS_SEL (at 0xF99C4074) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x15 " [   21]   SW_EVENTS_ZERO                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x13--0x14 " [20:19]   SW_EVENTS_SEL                            = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x12 " [   18]   BAM_DATA_ERASE                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11 " [   17]   BAM_DATA_FLUSH                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   BAM_CLK_ALWAYS_ON                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x0--0x6 1  " [06:00]   BAM_TESTBUS_SEL                          = " 
        textline ""
      tree.end
      tree "BAM_TEST_BUS_REG"
        group.long 0x78--0x7B "BAM_TEST_BUS_REG (at 0xF99C4078) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   BAM_TESTBUS_REG                          = " 
        textline ""
      tree.end
      tree "BAM_CNFG_BITS"
        group.long 0x7C--0x7F "BAM_CNFG_BITS (at 0xF99C407C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1C " [   28]   BAM_ZLT_W_CD_SUPPORT                     = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1B " [   27]   BAM_CD_ENABLE                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1A " [   26]   BAM_AU_ACCUMED                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x19 " [   25]   BAM_PSM_P_HD_DATA                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_REG_P_EN                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_WB_DSC_AVL_P_RST                     = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_WB_RETR_SVPNT                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_WB_CSW_ACK_IDL                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_WB_BLK_CSW                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x13 " [   19]   BAM_WB_P_RES                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x12 " [   18]   BAM_SI_P_RES                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11 " [   17]   BAM_AU_P_RES                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   BAM_PSM_P_RES                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0xF " [   15]   BAM_PSM_CSW_REQ                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0xE " [   14]   BAM_SB_CLK_REQ                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0xD " [   13]   BAM_IBC_DISABLE                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0xC " [   12]   BAM_NO_EXT_P_RST                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0xB " [   11]   BAM_FULL_PIPE                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   BAM_ADML_SYNC_BRIDGE                     = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_PIPE_CNFG                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_ADML_DEEP_CONS_FIFO                  = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   BAM_ADML_INCR4_EN_N                      = "  "0,1"
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE0"
        group.long 0x800--0x803 "BAM_IRQ_SRCS_EE0 (at 0xF99C4800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE1"
        group.long 0x880--0x883 "BAM_IRQ_SRCS_EE1 (at 0xF99C4880) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE2"
        group.long 0x900--0x903 "BAM_IRQ_SRCS_EE2 (at 0xF99C4900) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE3"
        group.long 0x980--0x983 "BAM_IRQ_SRCS_EE3 (at 0xF99C4980) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE4"
        group.long 0xA00--0xA03 "BAM_IRQ_SRCS_EE4 (at 0xF99C4A00) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE5"
        group.long 0xA80--0xA83 "BAM_IRQ_SRCS_EE5 (at 0xF99C4A80) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE6"
        group.long 0xB00--0xB03 "BAM_IRQ_SRCS_EE6 (at 0xF99C4B00) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE7"
        group.long 0xB80--0xB83 "BAM_IRQ_SRCS_EE7 (at 0xF99C4B80) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE0"
        group.long 0x804--0x807 "BAM_IRQ_SRCS_MSK_EE0 (at 0xF99C4804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE1"
        group.long 0x884--0x887 "BAM_IRQ_SRCS_MSK_EE1 (at 0xF99C4884) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE2"
        group.long 0x904--0x907 "BAM_IRQ_SRCS_MSK_EE2 (at 0xF99C4904) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE3"
        group.long 0x984--0x987 "BAM_IRQ_SRCS_MSK_EE3 (at 0xF99C4984) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE4"
        group.long 0xA04--0xA07 "BAM_IRQ_SRCS_MSK_EE4 (at 0xF99C4A04) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE5"
        group.long 0xA84--0xA87 "BAM_IRQ_SRCS_MSK_EE5 (at 0xF99C4A84) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE6"
        group.long 0xB04--0xB07 "BAM_IRQ_SRCS_MSK_EE6 (at 0xF99C4B04) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE7"
        group.long 0xB84--0xB87 "BAM_IRQ_SRCS_MSK_EE7 (at 0xF99C4B84) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE0"
        group.long 0x808--0x80B "BAM_IRQ_SRCS_UNMASKED_EE0 (at 0xF99C4808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE1"
        group.long 0x888--0x88B "BAM_IRQ_SRCS_UNMASKED_EE1 (at 0xF99C4888) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE2"
        group.long 0x908--0x90B "BAM_IRQ_SRCS_UNMASKED_EE2 (at 0xF99C4908) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE3"
        group.long 0x988--0x98B "BAM_IRQ_SRCS_UNMASKED_EE3 (at 0xF99C4988) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE4"
        group.long 0xA08--0xA0B "BAM_IRQ_SRCS_UNMASKED_EE4 (at 0xF99C4A08) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE5"
        group.long 0xA88--0xA8B "BAM_IRQ_SRCS_UNMASKED_EE5 (at 0xF99C4A88) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE6"
        group.long 0xB08--0xB0B "BAM_IRQ_SRCS_UNMASKED_EE6 (at 0xF99C4B08) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE7"
        group.long 0xB88--0xB8B "BAM_IRQ_SRCS_UNMASKED_EE7 (at 0xF99C4B88) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
;End of BAM Control Registers
tree.end
tree "Pipe 0"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL0"
        group.long 0x1000--0x1003 "BAM_P_CTRL0 (at 0xF99C5000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST0"
        group.long 0x1004--0x1007 "BAM_P_RST0 (at 0xF99C5004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT0"
        group.long 0x1008--0x100B "BAM_P_HALT0 (at 0xF99C5008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG0"
        group.long 0x1030--0x1033 "BAM_P_TRUST_REG0 (at 0xF99C5030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS0"
        group.long 0x1010--0x1013 "BAM_P_IRQ_STTS0 (at 0xF99C5010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR0"
        group.long 0x1014--0x1017 "BAM_P_IRQ_CLR0 (at 0xF99C5014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN0"
        group.long 0x1018--0x101B "BAM_P_IRQ_EN0 (at 0xF99C5018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER0"
        group.long 0x101C--0x101F "BAM_P_TIMER0 (at 0xF99C501C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL0"
        group.long 0x1020--0x1023 "BAM_P_TIMER_CTRL0 (at 0xF99C5020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND0"
        group.long 0x1024--0x1027 "BAM_P_PRDCR_SDBND0 (at 0xF99C5024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND0"
        group.long 0x1028--0x102B "BAM_P_CNSMR_SDBND0 (at 0xF99C5028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR0"
        group.long 0x182C--0x182F "BAM_P_EVNT_DEST_ADDR0 (at 0xF99C582C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG0"
        group.long 0x1818--0x181B "BAM_P_EVNT_REG0 (at 0xF99C5818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS0"
        group.long 0x1800--0x1803 "BAM_P_SW_OFSTS0 (at 0xF99C5800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR0"
        group.long 0x1824--0x1827 "BAM_P_DATA_FIFO_ADDR0 (at 0xF99C5824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR0"
        group.long 0x181C--0x181F "BAM_P_DESC_FIFO_ADDR0 (at 0xF99C581C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD0"
        group.long 0x1828--0x182B "BAM_P_EVNT_GEN_TRSHLD0 (at 0xF99C5828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES0"
        group.long 0x1820--0x1823 "BAM_P_FIFO_SIZES0 (at 0xF99C5820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_0"
        group.long 0x1834--0x1837 "BAM_P_RETR_CNTXT_0 (at 0xF99C5834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_0"
        group.long 0x1838--0x183B "BAM_P_SI_CNTXT_0 (at 0xF99C5838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_0"
        group.long 0x1830--0x1833 "BAM_P_DF_CNTXT_0 (at 0xF99C5830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_0"
        group.long 0x1804--0x1807 "BAM_P_AU_PSM_CNTXT_1_0 (at 0xF99C5804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_0"
        group.long 0x1808--0x180B "BAM_P_PSM_CNTXT_2_0 (at 0xF99C5808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_0"
        group.long 0x180C--0x180F "BAM_P_PSM_CNTXT_3_0 (at 0xF99C580C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_0"
        group.long 0x1810--0x1813 "BAM_P_PSM_CNTXT_4_0 (at 0xF99C5810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_0"
        group.long 0x1814--0x1817 "BAM_P_PSM_CNTXT_5_0 (at 0xF99C5814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 0
tree.end
tree "Pipe 1"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL1"
        group.long 0x2000--0x2003 "BAM_P_CTRL1 (at 0xF99C6000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST1"
        group.long 0x2004--0x2007 "BAM_P_RST1 (at 0xF99C6004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT1"
        group.long 0x2008--0x200B "BAM_P_HALT1 (at 0xF99C6008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG1"
        group.long 0x2030--0x2033 "BAM_P_TRUST_REG1 (at 0xF99C6030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS1"
        group.long 0x2010--0x2013 "BAM_P_IRQ_STTS1 (at 0xF99C6010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR1"
        group.long 0x2014--0x2017 "BAM_P_IRQ_CLR1 (at 0xF99C6014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN1"
        group.long 0x2018--0x201B "BAM_P_IRQ_EN1 (at 0xF99C6018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER1"
        group.long 0x201C--0x201F "BAM_P_TIMER1 (at 0xF99C601C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL1"
        group.long 0x2020--0x2023 "BAM_P_TIMER_CTRL1 (at 0xF99C6020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND1"
        group.long 0x2024--0x2027 "BAM_P_PRDCR_SDBND1 (at 0xF99C6024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND1"
        group.long 0x2028--0x202B "BAM_P_CNSMR_SDBND1 (at 0xF99C6028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR1"
        group.long 0x282C--0x282F "BAM_P_EVNT_DEST_ADDR1 (at 0xF99C682C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG1"
        group.long 0x2818--0x281B "BAM_P_EVNT_REG1 (at 0xF99C6818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS1"
        group.long 0x2800--0x2803 "BAM_P_SW_OFSTS1 (at 0xF99C6800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR1"
        group.long 0x2824--0x2827 "BAM_P_DATA_FIFO_ADDR1 (at 0xF99C6824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR1"
        group.long 0x281C--0x281F "BAM_P_DESC_FIFO_ADDR1 (at 0xF99C681C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD1"
        group.long 0x2828--0x282B "BAM_P_EVNT_GEN_TRSHLD1 (at 0xF99C6828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES1"
        group.long 0x2820--0x2823 "BAM_P_FIFO_SIZES1 (at 0xF99C6820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_1"
        group.long 0x2834--0x2837 "BAM_P_RETR_CNTXT_1 (at 0xF99C6834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_1"
        group.long 0x2838--0x283B "BAM_P_SI_CNTXT_1 (at 0xF99C6838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_1"
        group.long 0x2830--0x2833 "BAM_P_DF_CNTXT_1 (at 0xF99C6830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_1"
        group.long 0x2804--0x2807 "BAM_P_AU_PSM_CNTXT_1_1 (at 0xF99C6804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_1"
        group.long 0x2808--0x280B "BAM_P_PSM_CNTXT_2_1 (at 0xF99C6808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_1"
        group.long 0x280C--0x280F "BAM_P_PSM_CNTXT_3_1 (at 0xF99C680C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_1"
        group.long 0x2810--0x2813 "BAM_P_PSM_CNTXT_4_1 (at 0xF99C6810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_1"
        group.long 0x2814--0x2817 "BAM_P_PSM_CNTXT_5_1 (at 0xF99C6814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 1
tree.end
tree "Pipe 2"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL2"
        group.long 0x3000--0x3003 "BAM_P_CTRL2 (at 0xF99C7000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST2"
        group.long 0x3004--0x3007 "BAM_P_RST2 (at 0xF99C7004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT2"
        group.long 0x3008--0x300B "BAM_P_HALT2 (at 0xF99C7008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG2"
        group.long 0x3030--0x3033 "BAM_P_TRUST_REG2 (at 0xF99C7030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS2"
        group.long 0x3010--0x3013 "BAM_P_IRQ_STTS2 (at 0xF99C7010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR2"
        group.long 0x3014--0x3017 "BAM_P_IRQ_CLR2 (at 0xF99C7014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN2"
        group.long 0x3018--0x301B "BAM_P_IRQ_EN2 (at 0xF99C7018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER2"
        group.long 0x301C--0x301F "BAM_P_TIMER2 (at 0xF99C701C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL2"
        group.long 0x3020--0x3023 "BAM_P_TIMER_CTRL2 (at 0xF99C7020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND2"
        group.long 0x3024--0x3027 "BAM_P_PRDCR_SDBND2 (at 0xF99C7024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND2"
        group.long 0x3028--0x302B "BAM_P_CNSMR_SDBND2 (at 0xF99C7028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR2"
        group.long 0x382C--0x382F "BAM_P_EVNT_DEST_ADDR2 (at 0xF99C782C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG2"
        group.long 0x3818--0x381B "BAM_P_EVNT_REG2 (at 0xF99C7818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS2"
        group.long 0x3800--0x3803 "BAM_P_SW_OFSTS2 (at 0xF99C7800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR2"
        group.long 0x3824--0x3827 "BAM_P_DATA_FIFO_ADDR2 (at 0xF99C7824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR2"
        group.long 0x381C--0x381F "BAM_P_DESC_FIFO_ADDR2 (at 0xF99C781C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD2"
        group.long 0x3828--0x382B "BAM_P_EVNT_GEN_TRSHLD2 (at 0xF99C7828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES2"
        group.long 0x3820--0x3823 "BAM_P_FIFO_SIZES2 (at 0xF99C7820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_2"
        group.long 0x3834--0x3837 "BAM_P_RETR_CNTXT_2 (at 0xF99C7834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_2"
        group.long 0x3838--0x383B "BAM_P_SI_CNTXT_2 (at 0xF99C7838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_2"
        group.long 0x3830--0x3833 "BAM_P_DF_CNTXT_2 (at 0xF99C7830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_2"
        group.long 0x3804--0x3807 "BAM_P_AU_PSM_CNTXT_1_2 (at 0xF99C7804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_2"
        group.long 0x3808--0x380B "BAM_P_PSM_CNTXT_2_2 (at 0xF99C7808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_2"
        group.long 0x380C--0x380F "BAM_P_PSM_CNTXT_3_2 (at 0xF99C780C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_2"
        group.long 0x3810--0x3813 "BAM_P_PSM_CNTXT_4_2 (at 0xF99C7810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_2"
        group.long 0x3814--0x3817 "BAM_P_PSM_CNTXT_5_2 (at 0xF99C7814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 2
tree.end
tree "Pipe 3"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL3"
        group.long 0x4000--0x4003 "BAM_P_CTRL3 (at 0xF99C8000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST3"
        group.long 0x4004--0x4007 "BAM_P_RST3 (at 0xF99C8004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT3"
        group.long 0x4008--0x400B "BAM_P_HALT3 (at 0xF99C8008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG3"
        group.long 0x4030--0x4033 "BAM_P_TRUST_REG3 (at 0xF99C8030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS3"
        group.long 0x4010--0x4013 "BAM_P_IRQ_STTS3 (at 0xF99C8010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR3"
        group.long 0x4014--0x4017 "BAM_P_IRQ_CLR3 (at 0xF99C8014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN3"
        group.long 0x4018--0x401B "BAM_P_IRQ_EN3 (at 0xF99C8018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER3"
        group.long 0x401C--0x401F "BAM_P_TIMER3 (at 0xF99C801C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL3"
        group.long 0x4020--0x4023 "BAM_P_TIMER_CTRL3 (at 0xF99C8020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND3"
        group.long 0x4024--0x4027 "BAM_P_PRDCR_SDBND3 (at 0xF99C8024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND3"
        group.long 0x4028--0x402B "BAM_P_CNSMR_SDBND3 (at 0xF99C8028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR3"
        group.long 0x482C--0x482F "BAM_P_EVNT_DEST_ADDR3 (at 0xF99C882C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG3"
        group.long 0x4818--0x481B "BAM_P_EVNT_REG3 (at 0xF99C8818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS3"
        group.long 0x4800--0x4803 "BAM_P_SW_OFSTS3 (at 0xF99C8800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR3"
        group.long 0x4824--0x4827 "BAM_P_DATA_FIFO_ADDR3 (at 0xF99C8824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR3"
        group.long 0x481C--0x481F "BAM_P_DESC_FIFO_ADDR3 (at 0xF99C881C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD3"
        group.long 0x4828--0x482B "BAM_P_EVNT_GEN_TRSHLD3 (at 0xF99C8828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES3"
        group.long 0x4820--0x4823 "BAM_P_FIFO_SIZES3 (at 0xF99C8820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_3"
        group.long 0x4834--0x4837 "BAM_P_RETR_CNTXT_3 (at 0xF99C8834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_3"
        group.long 0x4838--0x483B "BAM_P_SI_CNTXT_3 (at 0xF99C8838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_3"
        group.long 0x4830--0x4833 "BAM_P_DF_CNTXT_3 (at 0xF99C8830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_3"
        group.long 0x4804--0x4807 "BAM_P_AU_PSM_CNTXT_1_3 (at 0xF99C8804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_3"
        group.long 0x4808--0x480B "BAM_P_PSM_CNTXT_2_3 (at 0xF99C8808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_3"
        group.long 0x480C--0x480F "BAM_P_PSM_CNTXT_3_3 (at 0xF99C880C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_3"
        group.long 0x4810--0x4813 "BAM_P_PSM_CNTXT_4_3 (at 0xF99C8810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_3"
        group.long 0x4814--0x4817 "BAM_P_PSM_CNTXT_5_3 (at 0xF99C8814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 3
tree.end
tree "Pipe 4"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL4"
        group.long 0x5000--0x5003 "BAM_P_CTRL4 (at 0xF99C9000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST4"
        group.long 0x5004--0x5007 "BAM_P_RST4 (at 0xF99C9004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT4"
        group.long 0x5008--0x500B "BAM_P_HALT4 (at 0xF99C9008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG4"
        group.long 0x5030--0x5033 "BAM_P_TRUST_REG4 (at 0xF99C9030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS4"
        group.long 0x5010--0x5013 "BAM_P_IRQ_STTS4 (at 0xF99C9010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR4"
        group.long 0x5014--0x5017 "BAM_P_IRQ_CLR4 (at 0xF99C9014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN4"
        group.long 0x5018--0x501B "BAM_P_IRQ_EN4 (at 0xF99C9018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER4"
        group.long 0x501C--0x501F "BAM_P_TIMER4 (at 0xF99C901C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL4"
        group.long 0x5020--0x5023 "BAM_P_TIMER_CTRL4 (at 0xF99C9020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND4"
        group.long 0x5024--0x5027 "BAM_P_PRDCR_SDBND4 (at 0xF99C9024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND4"
        group.long 0x5028--0x502B "BAM_P_CNSMR_SDBND4 (at 0xF99C9028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR4"
        group.long 0x582C--0x582F "BAM_P_EVNT_DEST_ADDR4 (at 0xF99C982C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG4"
        group.long 0x5818--0x581B "BAM_P_EVNT_REG4 (at 0xF99C9818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS4"
        group.long 0x5800--0x5803 "BAM_P_SW_OFSTS4 (at 0xF99C9800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR4"
        group.long 0x5824--0x5827 "BAM_P_DATA_FIFO_ADDR4 (at 0xF99C9824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR4"
        group.long 0x581C--0x581F "BAM_P_DESC_FIFO_ADDR4 (at 0xF99C981C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD4"
        group.long 0x5828--0x582B "BAM_P_EVNT_GEN_TRSHLD4 (at 0xF99C9828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES4"
        group.long 0x5820--0x5823 "BAM_P_FIFO_SIZES4 (at 0xF99C9820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_4"
        group.long 0x5834--0x5837 "BAM_P_RETR_CNTXT_4 (at 0xF99C9834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_4"
        group.long 0x5838--0x583B "BAM_P_SI_CNTXT_4 (at 0xF99C9838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_4"
        group.long 0x5830--0x5833 "BAM_P_DF_CNTXT_4 (at 0xF99C9830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_4"
        group.long 0x5804--0x5807 "BAM_P_AU_PSM_CNTXT_1_4 (at 0xF99C9804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_4"
        group.long 0x5808--0x580B "BAM_P_PSM_CNTXT_2_4 (at 0xF99C9808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_4"
        group.long 0x580C--0x580F "BAM_P_PSM_CNTXT_3_4 (at 0xF99C980C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_4"
        group.long 0x5810--0x5813 "BAM_P_PSM_CNTXT_4_4 (at 0xF99C9810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_4"
        group.long 0x5814--0x5817 "BAM_P_PSM_CNTXT_5_4 (at 0xF99C9814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 4
tree.end
tree "Pipe 5"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL5"
        group.long 0x6000--0x6003 "BAM_P_CTRL5 (at 0xF99CA000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST5"
        group.long 0x6004--0x6007 "BAM_P_RST5 (at 0xF99CA004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT5"
        group.long 0x6008--0x600B "BAM_P_HALT5 (at 0xF99CA008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG5"
        group.long 0x6030--0x6033 "BAM_P_TRUST_REG5 (at 0xF99CA030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS5"
        group.long 0x6010--0x6013 "BAM_P_IRQ_STTS5 (at 0xF99CA010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR5"
        group.long 0x6014--0x6017 "BAM_P_IRQ_CLR5 (at 0xF99CA014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN5"
        group.long 0x6018--0x601B "BAM_P_IRQ_EN5 (at 0xF99CA018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER5"
        group.long 0x601C--0x601F "BAM_P_TIMER5 (at 0xF99CA01C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL5"
        group.long 0x6020--0x6023 "BAM_P_TIMER_CTRL5 (at 0xF99CA020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND5"
        group.long 0x6024--0x6027 "BAM_P_PRDCR_SDBND5 (at 0xF99CA024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND5"
        group.long 0x6028--0x602B "BAM_P_CNSMR_SDBND5 (at 0xF99CA028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR5"
        group.long 0x682C--0x682F "BAM_P_EVNT_DEST_ADDR5 (at 0xF99CA82C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG5"
        group.long 0x6818--0x681B "BAM_P_EVNT_REG5 (at 0xF99CA818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS5"
        group.long 0x6800--0x6803 "BAM_P_SW_OFSTS5 (at 0xF99CA800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR5"
        group.long 0x6824--0x6827 "BAM_P_DATA_FIFO_ADDR5 (at 0xF99CA824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR5"
        group.long 0x681C--0x681F "BAM_P_DESC_FIFO_ADDR5 (at 0xF99CA81C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD5"
        group.long 0x6828--0x682B "BAM_P_EVNT_GEN_TRSHLD5 (at 0xF99CA828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES5"
        group.long 0x6820--0x6823 "BAM_P_FIFO_SIZES5 (at 0xF99CA820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_5"
        group.long 0x6834--0x6837 "BAM_P_RETR_CNTXT_5 (at 0xF99CA834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_5"
        group.long 0x6838--0x683B "BAM_P_SI_CNTXT_5 (at 0xF99CA838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_5"
        group.long 0x6830--0x6833 "BAM_P_DF_CNTXT_5 (at 0xF99CA830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_5"
        group.long 0x6804--0x6807 "BAM_P_AU_PSM_CNTXT_1_5 (at 0xF99CA804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_5"
        group.long 0x6808--0x680B "BAM_P_PSM_CNTXT_2_5 (at 0xF99CA808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_5"
        group.long 0x680C--0x680F "BAM_P_PSM_CNTXT_3_5 (at 0xF99CA80C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_5"
        group.long 0x6810--0x6813 "BAM_P_PSM_CNTXT_4_5 (at 0xF99CA810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_5"
        group.long 0x6814--0x6817 "BAM_P_PSM_CNTXT_5_5 (at 0xF99CA814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 5
tree.end
tree "Pipe 6"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL6"
        group.long 0x7000--0x7003 "BAM_P_CTRL6 (at 0xF99CB000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST6"
        group.long 0x7004--0x7007 "BAM_P_RST6 (at 0xF99CB004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT6"
        group.long 0x7008--0x700B "BAM_P_HALT6 (at 0xF99CB008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG6"
        group.long 0x7030--0x7033 "BAM_P_TRUST_REG6 (at 0xF99CB030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS6"
        group.long 0x7010--0x7013 "BAM_P_IRQ_STTS6 (at 0xF99CB010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR6"
        group.long 0x7014--0x7017 "BAM_P_IRQ_CLR6 (at 0xF99CB014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN6"
        group.long 0x7018--0x701B "BAM_P_IRQ_EN6 (at 0xF99CB018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER6"
        group.long 0x701C--0x701F "BAM_P_TIMER6 (at 0xF99CB01C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL6"
        group.long 0x7020--0x7023 "BAM_P_TIMER_CTRL6 (at 0xF99CB020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND6"
        group.long 0x7024--0x7027 "BAM_P_PRDCR_SDBND6 (at 0xF99CB024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND6"
        group.long 0x7028--0x702B "BAM_P_CNSMR_SDBND6 (at 0xF99CB028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR6"
        group.long 0x782C--0x782F "BAM_P_EVNT_DEST_ADDR6 (at 0xF99CB82C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG6"
        group.long 0x7818--0x781B "BAM_P_EVNT_REG6 (at 0xF99CB818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS6"
        group.long 0x7800--0x7803 "BAM_P_SW_OFSTS6 (at 0xF99CB800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR6"
        group.long 0x7824--0x7827 "BAM_P_DATA_FIFO_ADDR6 (at 0xF99CB824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR6"
        group.long 0x781C--0x781F "BAM_P_DESC_FIFO_ADDR6 (at 0xF99CB81C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD6"
        group.long 0x7828--0x782B "BAM_P_EVNT_GEN_TRSHLD6 (at 0xF99CB828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES6"
        group.long 0x7820--0x7823 "BAM_P_FIFO_SIZES6 (at 0xF99CB820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_6"
        group.long 0x7834--0x7837 "BAM_P_RETR_CNTXT_6 (at 0xF99CB834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_6"
        group.long 0x7838--0x783B "BAM_P_SI_CNTXT_6 (at 0xF99CB838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_6"
        group.long 0x7830--0x7833 "BAM_P_DF_CNTXT_6 (at 0xF99CB830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_6"
        group.long 0x7804--0x7807 "BAM_P_AU_PSM_CNTXT_1_6 (at 0xF99CB804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_6"
        group.long 0x7808--0x780B "BAM_P_PSM_CNTXT_2_6 (at 0xF99CB808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_6"
        group.long 0x780C--0x780F "BAM_P_PSM_CNTXT_3_6 (at 0xF99CB80C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_6"
        group.long 0x7810--0x7813 "BAM_P_PSM_CNTXT_4_6 (at 0xF99CB810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_6"
        group.long 0x7814--0x7817 "BAM_P_PSM_CNTXT_5_6 (at 0xF99CB814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 6
tree.end
tree "Pipe 7"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL7"
        group.long 0x8000--0x8003 "BAM_P_CTRL7 (at 0xF99CC000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST7"
        group.long 0x8004--0x8007 "BAM_P_RST7 (at 0xF99CC004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT7"
        group.long 0x8008--0x800B "BAM_P_HALT7 (at 0xF99CC008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG7"
        group.long 0x8030--0x8033 "BAM_P_TRUST_REG7 (at 0xF99CC030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS7"
        group.long 0x8010--0x8013 "BAM_P_IRQ_STTS7 (at 0xF99CC010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR7"
        group.long 0x8014--0x8017 "BAM_P_IRQ_CLR7 (at 0xF99CC014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN7"
        group.long 0x8018--0x801B "BAM_P_IRQ_EN7 (at 0xF99CC018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER7"
        group.long 0x801C--0x801F "BAM_P_TIMER7 (at 0xF99CC01C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL7"
        group.long 0x8020--0x8023 "BAM_P_TIMER_CTRL7 (at 0xF99CC020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND7"
        group.long 0x8024--0x8027 "BAM_P_PRDCR_SDBND7 (at 0xF99CC024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND7"
        group.long 0x8028--0x802B "BAM_P_CNSMR_SDBND7 (at 0xF99CC028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR7"
        group.long 0x882C--0x882F "BAM_P_EVNT_DEST_ADDR7 (at 0xF99CC82C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG7"
        group.long 0x8818--0x881B "BAM_P_EVNT_REG7 (at 0xF99CC818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS7"
        group.long 0x8800--0x8803 "BAM_P_SW_OFSTS7 (at 0xF99CC800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR7"
        group.long 0x8824--0x8827 "BAM_P_DATA_FIFO_ADDR7 (at 0xF99CC824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR7"
        group.long 0x881C--0x881F "BAM_P_DESC_FIFO_ADDR7 (at 0xF99CC81C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD7"
        group.long 0x8828--0x882B "BAM_P_EVNT_GEN_TRSHLD7 (at 0xF99CC828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES7"
        group.long 0x8820--0x8823 "BAM_P_FIFO_SIZES7 (at 0xF99CC820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_7"
        group.long 0x8834--0x8837 "BAM_P_RETR_CNTXT_7 (at 0xF99CC834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_7"
        group.long 0x8838--0x883B "BAM_P_SI_CNTXT_7 (at 0xF99CC838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_7"
        group.long 0x8830--0x8833 "BAM_P_DF_CNTXT_7 (at 0xF99CC830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_7"
        group.long 0x8804--0x8807 "BAM_P_AU_PSM_CNTXT_1_7 (at 0xF99CC804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_7"
        group.long 0x8808--0x880B "BAM_P_PSM_CNTXT_2_7 (at 0xF99CC808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_7"
        group.long 0x880C--0x880F "BAM_P_PSM_CNTXT_3_7 (at 0xF99CC80C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_7"
        group.long 0x8810--0x8813 "BAM_P_PSM_CNTXT_4_7 (at 0xF99CC810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_7"
        group.long 0x8814--0x8817 "BAM_P_PSM_CNTXT_5_7 (at 0xF99CC814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 7
tree.end
tree "Pipe 8"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL8"
        group.long 0x9000--0x9003 "BAM_P_CTRL8 (at 0xF99CD000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST8"
        group.long 0x9004--0x9007 "BAM_P_RST8 (at 0xF99CD004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT8"
        group.long 0x9008--0x900B "BAM_P_HALT8 (at 0xF99CD008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG8"
        group.long 0x9030--0x9033 "BAM_P_TRUST_REG8 (at 0xF99CD030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS8"
        group.long 0x9010--0x9013 "BAM_P_IRQ_STTS8 (at 0xF99CD010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR8"
        group.long 0x9014--0x9017 "BAM_P_IRQ_CLR8 (at 0xF99CD014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN8"
        group.long 0x9018--0x901B "BAM_P_IRQ_EN8 (at 0xF99CD018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER8"
        group.long 0x901C--0x901F "BAM_P_TIMER8 (at 0xF99CD01C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL8"
        group.long 0x9020--0x9023 "BAM_P_TIMER_CTRL8 (at 0xF99CD020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND8"
        group.long 0x9024--0x9027 "BAM_P_PRDCR_SDBND8 (at 0xF99CD024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND8"
        group.long 0x9028--0x902B "BAM_P_CNSMR_SDBND8 (at 0xF99CD028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR8"
        group.long 0x982C--0x982F "BAM_P_EVNT_DEST_ADDR8 (at 0xF99CD82C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG8"
        group.long 0x9818--0x981B "BAM_P_EVNT_REG8 (at 0xF99CD818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS8"
        group.long 0x9800--0x9803 "BAM_P_SW_OFSTS8 (at 0xF99CD800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR8"
        group.long 0x9824--0x9827 "BAM_P_DATA_FIFO_ADDR8 (at 0xF99CD824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR8"
        group.long 0x981C--0x981F "BAM_P_DESC_FIFO_ADDR8 (at 0xF99CD81C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD8"
        group.long 0x9828--0x982B "BAM_P_EVNT_GEN_TRSHLD8 (at 0xF99CD828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES8"
        group.long 0x9820--0x9823 "BAM_P_FIFO_SIZES8 (at 0xF99CD820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_8"
        group.long 0x9834--0x9837 "BAM_P_RETR_CNTXT_8 (at 0xF99CD834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_8"
        group.long 0x9838--0x983B "BAM_P_SI_CNTXT_8 (at 0xF99CD838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_8"
        group.long 0x9830--0x9833 "BAM_P_DF_CNTXT_8 (at 0xF99CD830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_8"
        group.long 0x9804--0x9807 "BAM_P_AU_PSM_CNTXT_1_8 (at 0xF99CD804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_8"
        group.long 0x9808--0x980B "BAM_P_PSM_CNTXT_2_8 (at 0xF99CD808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_8"
        group.long 0x980C--0x980F "BAM_P_PSM_CNTXT_3_8 (at 0xF99CD80C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_8"
        group.long 0x9810--0x9813 "BAM_P_PSM_CNTXT_4_8 (at 0xF99CD810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_8"
        group.long 0x9814--0x9817 "BAM_P_PSM_CNTXT_5_8 (at 0xF99CD814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 8
tree.end
tree "Pipe 9"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL9"
        group.long 0xA000--0xA003 "BAM_P_CTRL9 (at 0xF99CE000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST9"
        group.long 0xA004--0xA007 "BAM_P_RST9 (at 0xF99CE004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT9"
        group.long 0xA008--0xA00B "BAM_P_HALT9 (at 0xF99CE008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG9"
        group.long 0xA030--0xA033 "BAM_P_TRUST_REG9 (at 0xF99CE030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS9"
        group.long 0xA010--0xA013 "BAM_P_IRQ_STTS9 (at 0xF99CE010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR9"
        group.long 0xA014--0xA017 "BAM_P_IRQ_CLR9 (at 0xF99CE014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN9"
        group.long 0xA018--0xA01B "BAM_P_IRQ_EN9 (at 0xF99CE018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER9"
        group.long 0xA01C--0xA01F "BAM_P_TIMER9 (at 0xF99CE01C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL9"
        group.long 0xA020--0xA023 "BAM_P_TIMER_CTRL9 (at 0xF99CE020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND9"
        group.long 0xA024--0xA027 "BAM_P_PRDCR_SDBND9 (at 0xF99CE024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND9"
        group.long 0xA028--0xA02B "BAM_P_CNSMR_SDBND9 (at 0xF99CE028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR9"
        group.long 0xA82C--0xA82F "BAM_P_EVNT_DEST_ADDR9 (at 0xF99CE82C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG9"
        group.long 0xA818--0xA81B "BAM_P_EVNT_REG9 (at 0xF99CE818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS9"
        group.long 0xA800--0xA803 "BAM_P_SW_OFSTS9 (at 0xF99CE800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR9"
        group.long 0xA824--0xA827 "BAM_P_DATA_FIFO_ADDR9 (at 0xF99CE824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR9"
        group.long 0xA81C--0xA81F "BAM_P_DESC_FIFO_ADDR9 (at 0xF99CE81C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD9"
        group.long 0xA828--0xA82B "BAM_P_EVNT_GEN_TRSHLD9 (at 0xF99CE828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES9"
        group.long 0xA820--0xA823 "BAM_P_FIFO_SIZES9 (at 0xF99CE820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_9"
        group.long 0xA834--0xA837 "BAM_P_RETR_CNTXT_9 (at 0xF99CE834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_9"
        group.long 0xA838--0xA83B "BAM_P_SI_CNTXT_9 (at 0xF99CE838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_9"
        group.long 0xA830--0xA833 "BAM_P_DF_CNTXT_9 (at 0xF99CE830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_9"
        group.long 0xA804--0xA807 "BAM_P_AU_PSM_CNTXT_1_9 (at 0xF99CE804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_9"
        group.long 0xA808--0xA80B "BAM_P_PSM_CNTXT_2_9 (at 0xF99CE808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_9"
        group.long 0xA80C--0xA80F "BAM_P_PSM_CNTXT_3_9 (at 0xF99CE80C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_9"
        group.long 0xA810--0xA813 "BAM_P_PSM_CNTXT_4_9 (at 0xF99CE810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_9"
        group.long 0xA814--0xA817 "BAM_P_PSM_CNTXT_5_9 (at 0xF99CE814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 9
tree.end
tree "Pipe 10"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL10"
        group.long 0xB000--0xB003 "BAM_P_CTRL10 (at 0xF99CF000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST10"
        group.long 0xB004--0xB007 "BAM_P_RST10 (at 0xF99CF004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT10"
        group.long 0xB008--0xB00B "BAM_P_HALT10 (at 0xF99CF008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG10"
        group.long 0xB030--0xB033 "BAM_P_TRUST_REG10 (at 0xF99CF030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS10"
        group.long 0xB010--0xB013 "BAM_P_IRQ_STTS10 (at 0xF99CF010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR10"
        group.long 0xB014--0xB017 "BAM_P_IRQ_CLR10 (at 0xF99CF014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN10"
        group.long 0xB018--0xB01B "BAM_P_IRQ_EN10 (at 0xF99CF018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER10"
        group.long 0xB01C--0xB01F "BAM_P_TIMER10 (at 0xF99CF01C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL10"
        group.long 0xB020--0xB023 "BAM_P_TIMER_CTRL10 (at 0xF99CF020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND10"
        group.long 0xB024--0xB027 "BAM_P_PRDCR_SDBND10 (at 0xF99CF024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND10"
        group.long 0xB028--0xB02B "BAM_P_CNSMR_SDBND10 (at 0xF99CF028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR10"
        group.long 0xB82C--0xB82F "BAM_P_EVNT_DEST_ADDR10 (at 0xF99CF82C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG10"
        group.long 0xB818--0xB81B "BAM_P_EVNT_REG10 (at 0xF99CF818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS10"
        group.long 0xB800--0xB803 "BAM_P_SW_OFSTS10 (at 0xF99CF800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR10"
        group.long 0xB824--0xB827 "BAM_P_DATA_FIFO_ADDR10 (at 0xF99CF824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR10"
        group.long 0xB81C--0xB81F "BAM_P_DESC_FIFO_ADDR10 (at 0xF99CF81C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD10"
        group.long 0xB828--0xB82B "BAM_P_EVNT_GEN_TRSHLD10 (at 0xF99CF828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES10"
        group.long 0xB820--0xB823 "BAM_P_FIFO_SIZES10 (at 0xF99CF820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_10"
        group.long 0xB834--0xB837 "BAM_P_RETR_CNTXT_10 (at 0xF99CF834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_10"
        group.long 0xB838--0xB83B "BAM_P_SI_CNTXT_10 (at 0xF99CF838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_10"
        group.long 0xB830--0xB833 "BAM_P_DF_CNTXT_10 (at 0xF99CF830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_10"
        group.long 0xB804--0xB807 "BAM_P_AU_PSM_CNTXT_1_10 (at 0xF99CF804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_10"
        group.long 0xB808--0xB80B "BAM_P_PSM_CNTXT_2_10 (at 0xF99CF808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_10"
        group.long 0xB80C--0xB80F "BAM_P_PSM_CNTXT_3_10 (at 0xF99CF80C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_10"
        group.long 0xB810--0xB813 "BAM_P_PSM_CNTXT_4_10 (at 0xF99CF810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_10"
        group.long 0xB814--0xB817 "BAM_P_PSM_CNTXT_5_10 (at 0xF99CF814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 10
tree.end
tree "Pipe 11"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL11"
        group.long 0xC000--0xC003 "BAM_P_CTRL11 (at 0xF99D0000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST11"
        group.long 0xC004--0xC007 "BAM_P_RST11 (at 0xF99D0004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT11"
        group.long 0xC008--0xC00B "BAM_P_HALT11 (at 0xF99D0008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG11"
        group.long 0xC030--0xC033 "BAM_P_TRUST_REG11 (at 0xF99D0030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS11"
        group.long 0xC010--0xC013 "BAM_P_IRQ_STTS11 (at 0xF99D0010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR11"
        group.long 0xC014--0xC017 "BAM_P_IRQ_CLR11 (at 0xF99D0014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN11"
        group.long 0xC018--0xC01B "BAM_P_IRQ_EN11 (at 0xF99D0018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER11"
        group.long 0xC01C--0xC01F "BAM_P_TIMER11 (at 0xF99D001C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL11"
        group.long 0xC020--0xC023 "BAM_P_TIMER_CTRL11 (at 0xF99D0020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND11"
        group.long 0xC024--0xC027 "BAM_P_PRDCR_SDBND11 (at 0xF99D0024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND11"
        group.long 0xC028--0xC02B "BAM_P_CNSMR_SDBND11 (at 0xF99D0028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR11"
        group.long 0xC82C--0xC82F "BAM_P_EVNT_DEST_ADDR11 (at 0xF99D082C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG11"
        group.long 0xC818--0xC81B "BAM_P_EVNT_REG11 (at 0xF99D0818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS11"
        group.long 0xC800--0xC803 "BAM_P_SW_OFSTS11 (at 0xF99D0800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR11"
        group.long 0xC824--0xC827 "BAM_P_DATA_FIFO_ADDR11 (at 0xF99D0824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR11"
        group.long 0xC81C--0xC81F "BAM_P_DESC_FIFO_ADDR11 (at 0xF99D081C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD11"
        group.long 0xC828--0xC82B "BAM_P_EVNT_GEN_TRSHLD11 (at 0xF99D0828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES11"
        group.long 0xC820--0xC823 "BAM_P_FIFO_SIZES11 (at 0xF99D0820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_11"
        group.long 0xC834--0xC837 "BAM_P_RETR_CNTXT_11 (at 0xF99D0834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_11"
        group.long 0xC838--0xC83B "BAM_P_SI_CNTXT_11 (at 0xF99D0838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_11"
        group.long 0xC830--0xC833 "BAM_P_DF_CNTXT_11 (at 0xF99D0830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_11"
        group.long 0xC804--0xC807 "BAM_P_AU_PSM_CNTXT_1_11 (at 0xF99D0804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_11"
        group.long 0xC808--0xC80B "BAM_P_PSM_CNTXT_2_11 (at 0xF99D0808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_11"
        group.long 0xC80C--0xC80F "BAM_P_PSM_CNTXT_3_11 (at 0xF99D080C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_11"
        group.long 0xC810--0xC813 "BAM_P_PSM_CNTXT_4_11 (at 0xF99D0810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_11"
        group.long 0xC814--0xC817 "BAM_P_PSM_CNTXT_5_11 (at 0xF99D0814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 11
tree.end
tree "Pipe 12"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL12"
        group.long 0xD000--0xD003 "BAM_P_CTRL12 (at 0xF99D1000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST12"
        group.long 0xD004--0xD007 "BAM_P_RST12 (at 0xF99D1004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT12"
        group.long 0xD008--0xD00B "BAM_P_HALT12 (at 0xF99D1008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG12"
        group.long 0xD030--0xD033 "BAM_P_TRUST_REG12 (at 0xF99D1030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS12"
        group.long 0xD010--0xD013 "BAM_P_IRQ_STTS12 (at 0xF99D1010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR12"
        group.long 0xD014--0xD017 "BAM_P_IRQ_CLR12 (at 0xF99D1014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN12"
        group.long 0xD018--0xD01B "BAM_P_IRQ_EN12 (at 0xF99D1018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER12"
        group.long 0xD01C--0xD01F "BAM_P_TIMER12 (at 0xF99D101C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL12"
        group.long 0xD020--0xD023 "BAM_P_TIMER_CTRL12 (at 0xF99D1020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND12"
        group.long 0xD024--0xD027 "BAM_P_PRDCR_SDBND12 (at 0xF99D1024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND12"
        group.long 0xD028--0xD02B "BAM_P_CNSMR_SDBND12 (at 0xF99D1028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR12"
        group.long 0xD82C--0xD82F "BAM_P_EVNT_DEST_ADDR12 (at 0xF99D182C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG12"
        group.long 0xD818--0xD81B "BAM_P_EVNT_REG12 (at 0xF99D1818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS12"
        group.long 0xD800--0xD803 "BAM_P_SW_OFSTS12 (at 0xF99D1800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR12"
        group.long 0xD824--0xD827 "BAM_P_DATA_FIFO_ADDR12 (at 0xF99D1824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR12"
        group.long 0xD81C--0xD81F "BAM_P_DESC_FIFO_ADDR12 (at 0xF99D181C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD12"
        group.long 0xD828--0xD82B "BAM_P_EVNT_GEN_TRSHLD12 (at 0xF99D1828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES12"
        group.long 0xD820--0xD823 "BAM_P_FIFO_SIZES12 (at 0xF99D1820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_12"
        group.long 0xD834--0xD837 "BAM_P_RETR_CNTXT_12 (at 0xF99D1834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_12"
        group.long 0xD838--0xD83B "BAM_P_SI_CNTXT_12 (at 0xF99D1838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_12"
        group.long 0xD830--0xD833 "BAM_P_DF_CNTXT_12 (at 0xF99D1830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_12"
        group.long 0xD804--0xD807 "BAM_P_AU_PSM_CNTXT_1_12 (at 0xF99D1804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_12"
        group.long 0xD808--0xD80B "BAM_P_PSM_CNTXT_2_12 (at 0xF99D1808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_12"
        group.long 0xD80C--0xD80F "BAM_P_PSM_CNTXT_3_12 (at 0xF99D180C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_12"
        group.long 0xD810--0xD813 "BAM_P_PSM_CNTXT_4_12 (at 0xF99D1810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_12"
        group.long 0xD814--0xD817 "BAM_P_PSM_CNTXT_5_12 (at 0xF99D1814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 12
tree.end
tree "Pipe 13"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL13"
        group.long 0xE000--0xE003 "BAM_P_CTRL13 (at 0xF99D2000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST13"
        group.long 0xE004--0xE007 "BAM_P_RST13 (at 0xF99D2004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT13"
        group.long 0xE008--0xE00B "BAM_P_HALT13 (at 0xF99D2008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG13"
        group.long 0xE030--0xE033 "BAM_P_TRUST_REG13 (at 0xF99D2030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS13"
        group.long 0xE010--0xE013 "BAM_P_IRQ_STTS13 (at 0xF99D2010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR13"
        group.long 0xE014--0xE017 "BAM_P_IRQ_CLR13 (at 0xF99D2014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN13"
        group.long 0xE018--0xE01B "BAM_P_IRQ_EN13 (at 0xF99D2018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER13"
        group.long 0xE01C--0xE01F "BAM_P_TIMER13 (at 0xF99D201C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL13"
        group.long 0xE020--0xE023 "BAM_P_TIMER_CTRL13 (at 0xF99D2020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND13"
        group.long 0xE024--0xE027 "BAM_P_PRDCR_SDBND13 (at 0xF99D2024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND13"
        group.long 0xE028--0xE02B "BAM_P_CNSMR_SDBND13 (at 0xF99D2028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR13"
        group.long 0xE82C--0xE82F "BAM_P_EVNT_DEST_ADDR13 (at 0xF99D282C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG13"
        group.long 0xE818--0xE81B "BAM_P_EVNT_REG13 (at 0xF99D2818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS13"
        group.long 0xE800--0xE803 "BAM_P_SW_OFSTS13 (at 0xF99D2800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR13"
        group.long 0xE824--0xE827 "BAM_P_DATA_FIFO_ADDR13 (at 0xF99D2824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR13"
        group.long 0xE81C--0xE81F "BAM_P_DESC_FIFO_ADDR13 (at 0xF99D281C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD13"
        group.long 0xE828--0xE82B "BAM_P_EVNT_GEN_TRSHLD13 (at 0xF99D2828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES13"
        group.long 0xE820--0xE823 "BAM_P_FIFO_SIZES13 (at 0xF99D2820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_13"
        group.long 0xE834--0xE837 "BAM_P_RETR_CNTXT_13 (at 0xF99D2834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_13"
        group.long 0xE838--0xE83B "BAM_P_SI_CNTXT_13 (at 0xF99D2838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_13"
        group.long 0xE830--0xE833 "BAM_P_DF_CNTXT_13 (at 0xF99D2830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_13"
        group.long 0xE804--0xE807 "BAM_P_AU_PSM_CNTXT_1_13 (at 0xF99D2804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_13"
        group.long 0xE808--0xE80B "BAM_P_PSM_CNTXT_2_13 (at 0xF99D2808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_13"
        group.long 0xE80C--0xE80F "BAM_P_PSM_CNTXT_3_13 (at 0xF99D280C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_13"
        group.long 0xE810--0xE813 "BAM_P_PSM_CNTXT_4_13 (at 0xF99D2810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_13"
        group.long 0xE814--0xE817 "BAM_P_PSM_CNTXT_5_13 (at 0xF99D2814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 13
tree.end
tree "Pipe 14"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL14"
        group.long 0xF000--0xF003 "BAM_P_CTRL14 (at 0xF99D3000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST14"
        group.long 0xF004--0xF007 "BAM_P_RST14 (at 0xF99D3004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT14"
        group.long 0xF008--0xF00B "BAM_P_HALT14 (at 0xF99D3008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG14"
        group.long 0xF030--0xF033 "BAM_P_TRUST_REG14 (at 0xF99D3030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS14"
        group.long 0xF010--0xF013 "BAM_P_IRQ_STTS14 (at 0xF99D3010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR14"
        group.long 0xF014--0xF017 "BAM_P_IRQ_CLR14 (at 0xF99D3014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN14"
        group.long 0xF018--0xF01B "BAM_P_IRQ_EN14 (at 0xF99D3018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER14"
        group.long 0xF01C--0xF01F "BAM_P_TIMER14 (at 0xF99D301C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL14"
        group.long 0xF020--0xF023 "BAM_P_TIMER_CTRL14 (at 0xF99D3020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND14"
        group.long 0xF024--0xF027 "BAM_P_PRDCR_SDBND14 (at 0xF99D3024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND14"
        group.long 0xF028--0xF02B "BAM_P_CNSMR_SDBND14 (at 0xF99D3028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR14"
        group.long 0xF82C--0xF82F "BAM_P_EVNT_DEST_ADDR14 (at 0xF99D382C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG14"
        group.long 0xF818--0xF81B "BAM_P_EVNT_REG14 (at 0xF99D3818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS14"
        group.long 0xF800--0xF803 "BAM_P_SW_OFSTS14 (at 0xF99D3800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR14"
        group.long 0xF824--0xF827 "BAM_P_DATA_FIFO_ADDR14 (at 0xF99D3824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR14"
        group.long 0xF81C--0xF81F "BAM_P_DESC_FIFO_ADDR14 (at 0xF99D381C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD14"
        group.long 0xF828--0xF82B "BAM_P_EVNT_GEN_TRSHLD14 (at 0xF99D3828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES14"
        group.long 0xF820--0xF823 "BAM_P_FIFO_SIZES14 (at 0xF99D3820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_14"
        group.long 0xF834--0xF837 "BAM_P_RETR_CNTXT_14 (at 0xF99D3834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_14"
        group.long 0xF838--0xF83B "BAM_P_SI_CNTXT_14 (at 0xF99D3838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_14"
        group.long 0xF830--0xF833 "BAM_P_DF_CNTXT_14 (at 0xF99D3830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_14"
        group.long 0xF804--0xF807 "BAM_P_AU_PSM_CNTXT_1_14 (at 0xF99D3804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_14"
        group.long 0xF808--0xF80B "BAM_P_PSM_CNTXT_2_14 (at 0xF99D3808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_14"
        group.long 0xF80C--0xF80F "BAM_P_PSM_CNTXT_3_14 (at 0xF99D380C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_14"
        group.long 0xF810--0xF813 "BAM_P_PSM_CNTXT_4_14 (at 0xF99D3810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_14"
        group.long 0xF814--0xF817 "BAM_P_PSM_CNTXT_5_14 (at 0xF99D3814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 14
tree.end
tree "Pipe 15"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL15"
        group.long 0x10000--0x10003 "BAM_P_CTRL15 (at 0xF99D4000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST15"
        group.long 0x10004--0x10007 "BAM_P_RST15 (at 0xF99D4004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT15"
        group.long 0x10008--0x1000B "BAM_P_HALT15 (at 0xF99D4008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG15"
        group.long 0x10030--0x10033 "BAM_P_TRUST_REG15 (at 0xF99D4030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS15"
        group.long 0x10010--0x10013 "BAM_P_IRQ_STTS15 (at 0xF99D4010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR15"
        group.long 0x10014--0x10017 "BAM_P_IRQ_CLR15 (at 0xF99D4014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN15"
        group.long 0x10018--0x1001B "BAM_P_IRQ_EN15 (at 0xF99D4018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER15"
        group.long 0x1001C--0x1001F "BAM_P_TIMER15 (at 0xF99D401C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL15"
        group.long 0x10020--0x10023 "BAM_P_TIMER_CTRL15 (at 0xF99D4020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND15"
        group.long 0x10024--0x10027 "BAM_P_PRDCR_SDBND15 (at 0xF99D4024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND15"
        group.long 0x10028--0x1002B "BAM_P_CNSMR_SDBND15 (at 0xF99D4028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR15"
        group.long 0x1082C--0x1082F "BAM_P_EVNT_DEST_ADDR15 (at 0xF99D482C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG15"
        group.long 0x10818--0x1081B "BAM_P_EVNT_REG15 (at 0xF99D4818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS15"
        group.long 0x10800--0x10803 "BAM_P_SW_OFSTS15 (at 0xF99D4800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR15"
        group.long 0x10824--0x10827 "BAM_P_DATA_FIFO_ADDR15 (at 0xF99D4824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR15"
        group.long 0x1081C--0x1081F "BAM_P_DESC_FIFO_ADDR15 (at 0xF99D481C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD15"
        group.long 0x10828--0x1082B "BAM_P_EVNT_GEN_TRSHLD15 (at 0xF99D4828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES15"
        group.long 0x10820--0x10823 "BAM_P_FIFO_SIZES15 (at 0xF99D4820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_15"
        group.long 0x10834--0x10837 "BAM_P_RETR_CNTXT_15 (at 0xF99D4834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_15"
        group.long 0x10838--0x1083B "BAM_P_SI_CNTXT_15 (at 0xF99D4838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_15"
        group.long 0x10830--0x10833 "BAM_P_DF_CNTXT_15 (at 0xF99D4830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_15"
        group.long 0x10804--0x10807 "BAM_P_AU_PSM_CNTXT_1_15 (at 0xF99D4804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_15"
        group.long 0x10808--0x1080B "BAM_P_PSM_CNTXT_2_15 (at 0xF99D4808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_15"
        group.long 0x1080C--0x1080F "BAM_P_PSM_CNTXT_3_15 (at 0xF99D480C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_15"
        group.long 0x10810--0x10813 "BAM_P_PSM_CNTXT_4_15 (at 0xF99D4810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_15"
        group.long 0x10814--0x10817 "BAM_P_PSM_CNTXT_5_15 (at 0xF99D4814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 15
tree.end
tree.end
;Block Per Data Ends

base ad:0xF9A44000
tree "USB1_HS"
tree "BAM Control Registers"
      tree "BAM_CTRL"
        group.long 0x0--0x3 "BAM_CTRL (at 0xF9A44000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x13 " [   19]   CACHE_MISS_ERR_RESP_EN                   = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11--0x12 " [18:17]   LOCAL_CLK_GATING                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   IBC_DISABLE                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0xF " [   15]   BAM_CACHED_DESC_STORE                    = "  "0,1"
        textline ""
        bitfld.long 0x0 0xD--0xE " [14:13]   BAM_DESC_CACHE_SEL                       = "  "0,1,2,3"
        textline ""
        hexmask.long.word 0x0 0x5--0xB 1  " [11:05]   BAM_TESTBUS_SEL                          = " 
        textline ""
        bitfld.long 0x0 0x4 " [   04]   BAM_EN_ACCUM                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_EN                                   = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   BAM_SW_RST                               = "  "0,1"
        textline ""
      tree.end
      tree "BAM_REVISION"
        group.long 0x4--0x7 "BAM_REVISION (at 0xF9A44004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x18--0x1F 1  " [31:24]   INACTIV_TMR_BASE                         = " 
        textline ""
        bitfld.long 0x0 0x17 " [   23]   CMD_DESC_EN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15--0x16 " [22:21]   DESC_CACHE_DEPTH                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   NUM_INACTIV_TMRS                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x13 " [   19]   INACTIV_TMRS_EXST                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x12 " [   18]   HIGH_FREQUENCY_BAM                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11 " [   17]   BAM_HAS_NO_BYPASS                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   SECURED                                  = "  "0,1"
        textline ""
        bitfld.long 0x0 0xF " [   15]   USE_VMIDMT                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0xE " [   14]   AXI_ACTIVE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0xD " [   13]   CE_BUFFER_SIZE                           = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x8--0xB 1  " [11:08]   NUM_EES                                  = " 
        textline ""
        hexmask.long.word 0x0 0x0--0x7 1  " [07:00]   REVISION                                 = " 
        textline ""
      tree.end
      tree "BAM_SW_VERSION"
        group.long 0x80--0x83 "BAM_SW_VERSION (at 0xF9A44080) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x1C--0x1F 1  " [31:28]   MAJOR                                    = " 
        textline ""
        hexmask.long.word 0x0 0x10--0x1B 1  " [27:16]   MINOR                                    = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   STEP                                     = " 
        textline ""
      tree.end
      tree "BAM_NUM_PIPES"
        group.long 0x3C--0x3F "BAM_NUM_PIPES (at 0xF9A4403C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x18--0x1F 1  " [31:24]   BAM_NON_PIPE_GRP                         = " 
        textline ""
        hexmask.long.word 0x0 0x10--0x17 1  " [23:16]   PERIPH_NON_PIPE_GRP                      = " 
        textline ""
        hexmask.long.word 0x0 0x0--0x7 1  " [07:00]   BAM_NUM_PIPES                            = " 
        textline ""
      tree.end
      tree "BAM_TIMER"
        group.long 0x40--0x43 "BAM_TIMER (at 0xF9A44040) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   TIMER                                    = " 
        textline ""
      tree.end
      tree "BAM_TIMER_CTRL"
        group.long 0x44--0x47 "BAM_TIMER_CTRL (at 0xF9A44044) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   TIMER_RST                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   TIMER_RUN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   TIMER_MODE                               = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   TIMER_TRSHLD                             = " 
        textline ""
      tree.end
      tree "BAM_DESC_CNT_TRSHLD"
        group.long 0x8--0xB "BAM_DESC_CNT_TRSHLD (at 0xF9A44008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   CNT_TRSHLD                               = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS"
        group.long 0xC--0xF "BAM_IRQ_SRCS (at 0xF9A4400C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK"
        group.long 0x10--0x13 "BAM_IRQ_SRCS_MSK (at 0xF9A44010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED"
        group.long 0x30--0x33 "BAM_IRQ_SRCS_UNMASKED (at 0xF9A44030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_STTS"
        group.long 0x14--0x17 "BAM_IRQ_STTS (at 0xF9A44014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x4 " [   04]   BAM_TIMER_IRQ                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   BAM_EMPTY_IRQ                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_ERROR_IRQ                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_HRESP_ERR_IRQ                        = "  "0,1"
        textline ""
      tree.end
      tree "BAM_IRQ_CLR"
        group.long 0x18--0x1B "BAM_IRQ_CLR (at 0xF9A44018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x4 " [   04]   BAM_TIMER_CLR                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   BAM_EMPTY_CLR                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_ERROR_CLR                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_HRESP_ERR_CLR                        = "  "0,1"
        textline ""
      tree.end
      tree "BAM_IRQ_EN"
        group.long 0x1C--0x1F "BAM_IRQ_EN (at 0xF9A4401C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x4 " [   04]   BAM_TIMER_EN                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   BAM_EMPTY_EN                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_ERROR_EN                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_HRESP_ERR_EN                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_AHB_MASTER_ERR_CTRLS"
        group.long 0x24--0x27 "BAM_AHB_MASTER_ERR_CTRLS (at 0xF9A44024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x12--0x16 1  " [22:18]   BAM_ERR_HVMID                            = " 
        textline ""
        bitfld.long 0x0 0x11 " [   17]   BAM_ERR_DIRECT_MODE                      = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0xC--0x10 1  " [16:12]   BAM_ERR_HCID                             = " 
        textline ""
        hexmask.long.word 0x0 0x8--0xB 1  " [11:08]   BAM_ERR_HPROT                            = " 
        textline ""
        bitfld.long 0x0 0x5--0x7 " [07:05]   BAM_ERR_HBURST                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x3--0x4 " [04:03]   BAM_ERR_HSIZE                            = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_ERR_HWRITE                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0--0x1 " [01:00]   BAM_ERR_HTRANS                           = "  "0,1,2,3"
        textline ""
      tree.end
      tree "BAM_AHB_MASTER_ERR_ADDR"
        group.long 0x28--0x2B "BAM_AHB_MASTER_ERR_ADDR (at 0xF9A44028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   BAM_ERR_ADDR                             = " 
        textline ""
      tree.end
      tree "BAM_AHB_MASTER_ERR_DATA"
        group.long 0x2C--0x2F "BAM_AHB_MASTER_ERR_DATA (at 0xF9A4402C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   BAM_ERR_DATA                             = " 
        textline ""
      tree.end
      tree "BAM_TRUST_REG"
        group.long 0x70--0x73 "BAM_TRUST_REG (at 0xF9A44070) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0xD " [   13]   LOCK_EE_CTRL                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_VMID                                 = " 
        textline ""
        bitfld.long 0x0 0x7 " [   07]   BAM_RST_BLOCK                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_EE                                   = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_TEST_BUS_SEL"
        group.long 0x74--0x77 "BAM_TEST_BUS_SEL (at 0xF9A44074) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x15 " [   21]   SW_EVENTS_ZERO                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x13--0x14 " [20:19]   SW_EVENTS_SEL                            = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x12 " [   18]   BAM_DATA_ERASE                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11 " [   17]   BAM_DATA_FLUSH                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   BAM_CLK_ALWAYS_ON                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x0--0x6 1  " [06:00]   BAM_TESTBUS_SEL                          = " 
        textline ""
      tree.end
      tree "BAM_TEST_BUS_REG"
        group.long 0x78--0x7B "BAM_TEST_BUS_REG (at 0xF9A44078) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   BAM_TESTBUS_REG                          = " 
        textline ""
      tree.end
      tree "BAM_CNFG_BITS"
        group.long 0x7C--0x7F "BAM_CNFG_BITS (at 0xF9A4407C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1C " [   28]   BAM_ZLT_W_CD_SUPPORT                     = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1B " [   27]   BAM_CD_ENABLE                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1A " [   26]   BAM_AU_ACCUMED                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x19 " [   25]   BAM_PSM_P_HD_DATA                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_REG_P_EN                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_WB_DSC_AVL_P_RST                     = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_WB_RETR_SVPNT                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_WB_CSW_ACK_IDL                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_WB_BLK_CSW                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x13 " [   19]   BAM_WB_P_RES                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x12 " [   18]   BAM_SI_P_RES                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11 " [   17]   BAM_AU_P_RES                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   BAM_PSM_P_RES                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0xF " [   15]   BAM_PSM_CSW_REQ                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0xE " [   14]   BAM_SB_CLK_REQ                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0xD " [   13]   BAM_IBC_DISABLE                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0xC " [   12]   BAM_NO_EXT_P_RST                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0xB " [   11]   BAM_FULL_PIPE                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   BAM_ADML_SYNC_BRIDGE                     = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_PIPE_CNFG                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_ADML_DEEP_CONS_FIFO                  = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   BAM_ADML_INCR4_EN_N                      = "  "0,1"
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE0"
        group.long 0x800--0x803 "BAM_IRQ_SRCS_EE0 (at 0xF9A44800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE1"
        group.long 0x880--0x883 "BAM_IRQ_SRCS_EE1 (at 0xF9A44880) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE2"
        group.long 0x900--0x903 "BAM_IRQ_SRCS_EE2 (at 0xF9A44900) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE3"
        group.long 0x980--0x983 "BAM_IRQ_SRCS_EE3 (at 0xF9A44980) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE4"
        group.long 0xA00--0xA03 "BAM_IRQ_SRCS_EE4 (at 0xF9A44A00) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE5"
        group.long 0xA80--0xA83 "BAM_IRQ_SRCS_EE5 (at 0xF9A44A80) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE6"
        group.long 0xB00--0xB03 "BAM_IRQ_SRCS_EE6 (at 0xF9A44B00) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE7"
        group.long 0xB80--0xB83 "BAM_IRQ_SRCS_EE7 (at 0xF9A44B80) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE0"
        group.long 0x804--0x807 "BAM_IRQ_SRCS_MSK_EE0 (at 0xF9A44804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE1"
        group.long 0x884--0x887 "BAM_IRQ_SRCS_MSK_EE1 (at 0xF9A44884) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE2"
        group.long 0x904--0x907 "BAM_IRQ_SRCS_MSK_EE2 (at 0xF9A44904) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE3"
        group.long 0x984--0x987 "BAM_IRQ_SRCS_MSK_EE3 (at 0xF9A44984) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE4"
        group.long 0xA04--0xA07 "BAM_IRQ_SRCS_MSK_EE4 (at 0xF9A44A04) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE5"
        group.long 0xA84--0xA87 "BAM_IRQ_SRCS_MSK_EE5 (at 0xF9A44A84) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE6"
        group.long 0xB04--0xB07 "BAM_IRQ_SRCS_MSK_EE6 (at 0xF9A44B04) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE7"
        group.long 0xB84--0xB87 "BAM_IRQ_SRCS_MSK_EE7 (at 0xF9A44B84) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE0"
        group.long 0x808--0x80B "BAM_IRQ_SRCS_UNMASKED_EE0 (at 0xF9A44808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE1"
        group.long 0x888--0x88B "BAM_IRQ_SRCS_UNMASKED_EE1 (at 0xF9A44888) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE2"
        group.long 0x908--0x90B "BAM_IRQ_SRCS_UNMASKED_EE2 (at 0xF9A44908) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE3"
        group.long 0x988--0x98B "BAM_IRQ_SRCS_UNMASKED_EE3 (at 0xF9A44988) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE4"
        group.long 0xA08--0xA0B "BAM_IRQ_SRCS_UNMASKED_EE4 (at 0xF9A44A08) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE5"
        group.long 0xA88--0xA8B "BAM_IRQ_SRCS_UNMASKED_EE5 (at 0xF9A44A88) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE6"
        group.long 0xB08--0xB0B "BAM_IRQ_SRCS_UNMASKED_EE6 (at 0xF9A44B08) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE7"
        group.long 0xB88--0xB8B "BAM_IRQ_SRCS_UNMASKED_EE7 (at 0xF9A44B88) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
;End of BAM Control Registers
tree.end
tree "Pipe 0"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL0"
        group.long 0x1000--0x1003 "BAM_P_CTRL0 (at 0xF9A45000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST0"
        group.long 0x1004--0x1007 "BAM_P_RST0 (at 0xF9A45004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT0"
        group.long 0x1008--0x100B "BAM_P_HALT0 (at 0xF9A45008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG0"
        group.long 0x1030--0x1033 "BAM_P_TRUST_REG0 (at 0xF9A45030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS0"
        group.long 0x1010--0x1013 "BAM_P_IRQ_STTS0 (at 0xF9A45010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR0"
        group.long 0x1014--0x1017 "BAM_P_IRQ_CLR0 (at 0xF9A45014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN0"
        group.long 0x1018--0x101B "BAM_P_IRQ_EN0 (at 0xF9A45018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER0"
        group.long 0x101C--0x101F "BAM_P_TIMER0 (at 0xF9A4501C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL0"
        group.long 0x1020--0x1023 "BAM_P_TIMER_CTRL0 (at 0xF9A45020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND0"
        group.long 0x1024--0x1027 "BAM_P_PRDCR_SDBND0 (at 0xF9A45024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND0"
        group.long 0x1028--0x102B "BAM_P_CNSMR_SDBND0 (at 0xF9A45028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR0"
        group.long 0x182C--0x182F "BAM_P_EVNT_DEST_ADDR0 (at 0xF9A4582C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG0"
        group.long 0x1818--0x181B "BAM_P_EVNT_REG0 (at 0xF9A45818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS0"
        group.long 0x1800--0x1803 "BAM_P_SW_OFSTS0 (at 0xF9A45800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR0"
        group.long 0x1824--0x1827 "BAM_P_DATA_FIFO_ADDR0 (at 0xF9A45824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR0"
        group.long 0x181C--0x181F "BAM_P_DESC_FIFO_ADDR0 (at 0xF9A4581C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD0"
        group.long 0x1828--0x182B "BAM_P_EVNT_GEN_TRSHLD0 (at 0xF9A45828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES0"
        group.long 0x1820--0x1823 "BAM_P_FIFO_SIZES0 (at 0xF9A45820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_0"
        group.long 0x1834--0x1837 "BAM_P_RETR_CNTXT_0 (at 0xF9A45834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_0"
        group.long 0x1838--0x183B "BAM_P_SI_CNTXT_0 (at 0xF9A45838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_0"
        group.long 0x1830--0x1833 "BAM_P_DF_CNTXT_0 (at 0xF9A45830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_0"
        group.long 0x1804--0x1807 "BAM_P_AU_PSM_CNTXT_1_0 (at 0xF9A45804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_0"
        group.long 0x1808--0x180B "BAM_P_PSM_CNTXT_2_0 (at 0xF9A45808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_0"
        group.long 0x180C--0x180F "BAM_P_PSM_CNTXT_3_0 (at 0xF9A4580C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_0"
        group.long 0x1810--0x1813 "BAM_P_PSM_CNTXT_4_0 (at 0xF9A45810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_0"
        group.long 0x1814--0x1817 "BAM_P_PSM_CNTXT_5_0 (at 0xF9A45814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 0
tree.end
tree "Pipe 1"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL1"
        group.long 0x2000--0x2003 "BAM_P_CTRL1 (at 0xF9A46000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST1"
        group.long 0x2004--0x2007 "BAM_P_RST1 (at 0xF9A46004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT1"
        group.long 0x2008--0x200B "BAM_P_HALT1 (at 0xF9A46008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG1"
        group.long 0x2030--0x2033 "BAM_P_TRUST_REG1 (at 0xF9A46030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS1"
        group.long 0x2010--0x2013 "BAM_P_IRQ_STTS1 (at 0xF9A46010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR1"
        group.long 0x2014--0x2017 "BAM_P_IRQ_CLR1 (at 0xF9A46014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN1"
        group.long 0x2018--0x201B "BAM_P_IRQ_EN1 (at 0xF9A46018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER1"
        group.long 0x201C--0x201F "BAM_P_TIMER1 (at 0xF9A4601C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL1"
        group.long 0x2020--0x2023 "BAM_P_TIMER_CTRL1 (at 0xF9A46020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND1"
        group.long 0x2024--0x2027 "BAM_P_PRDCR_SDBND1 (at 0xF9A46024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND1"
        group.long 0x2028--0x202B "BAM_P_CNSMR_SDBND1 (at 0xF9A46028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR1"
        group.long 0x282C--0x282F "BAM_P_EVNT_DEST_ADDR1 (at 0xF9A4682C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG1"
        group.long 0x2818--0x281B "BAM_P_EVNT_REG1 (at 0xF9A46818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS1"
        group.long 0x2800--0x2803 "BAM_P_SW_OFSTS1 (at 0xF9A46800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR1"
        group.long 0x2824--0x2827 "BAM_P_DATA_FIFO_ADDR1 (at 0xF9A46824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR1"
        group.long 0x281C--0x281F "BAM_P_DESC_FIFO_ADDR1 (at 0xF9A4681C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD1"
        group.long 0x2828--0x282B "BAM_P_EVNT_GEN_TRSHLD1 (at 0xF9A46828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES1"
        group.long 0x2820--0x2823 "BAM_P_FIFO_SIZES1 (at 0xF9A46820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_1"
        group.long 0x2834--0x2837 "BAM_P_RETR_CNTXT_1 (at 0xF9A46834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_1"
        group.long 0x2838--0x283B "BAM_P_SI_CNTXT_1 (at 0xF9A46838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_1"
        group.long 0x2830--0x2833 "BAM_P_DF_CNTXT_1 (at 0xF9A46830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_1"
        group.long 0x2804--0x2807 "BAM_P_AU_PSM_CNTXT_1_1 (at 0xF9A46804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_1"
        group.long 0x2808--0x280B "BAM_P_PSM_CNTXT_2_1 (at 0xF9A46808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_1"
        group.long 0x280C--0x280F "BAM_P_PSM_CNTXT_3_1 (at 0xF9A4680C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_1"
        group.long 0x2810--0x2813 "BAM_P_PSM_CNTXT_4_1 (at 0xF9A46810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_1"
        group.long 0x2814--0x2817 "BAM_P_PSM_CNTXT_5_1 (at 0xF9A46814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 1
tree.end
tree "Pipe 2"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL2"
        group.long 0x3000--0x3003 "BAM_P_CTRL2 (at 0xF9A47000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST2"
        group.long 0x3004--0x3007 "BAM_P_RST2 (at 0xF9A47004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT2"
        group.long 0x3008--0x300B "BAM_P_HALT2 (at 0xF9A47008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG2"
        group.long 0x3030--0x3033 "BAM_P_TRUST_REG2 (at 0xF9A47030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS2"
        group.long 0x3010--0x3013 "BAM_P_IRQ_STTS2 (at 0xF9A47010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR2"
        group.long 0x3014--0x3017 "BAM_P_IRQ_CLR2 (at 0xF9A47014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN2"
        group.long 0x3018--0x301B "BAM_P_IRQ_EN2 (at 0xF9A47018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER2"
        group.long 0x301C--0x301F "BAM_P_TIMER2 (at 0xF9A4701C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL2"
        group.long 0x3020--0x3023 "BAM_P_TIMER_CTRL2 (at 0xF9A47020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND2"
        group.long 0x3024--0x3027 "BAM_P_PRDCR_SDBND2 (at 0xF9A47024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND2"
        group.long 0x3028--0x302B "BAM_P_CNSMR_SDBND2 (at 0xF9A47028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR2"
        group.long 0x382C--0x382F "BAM_P_EVNT_DEST_ADDR2 (at 0xF9A4782C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG2"
        group.long 0x3818--0x381B "BAM_P_EVNT_REG2 (at 0xF9A47818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS2"
        group.long 0x3800--0x3803 "BAM_P_SW_OFSTS2 (at 0xF9A47800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR2"
        group.long 0x3824--0x3827 "BAM_P_DATA_FIFO_ADDR2 (at 0xF9A47824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR2"
        group.long 0x381C--0x381F "BAM_P_DESC_FIFO_ADDR2 (at 0xF9A4781C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD2"
        group.long 0x3828--0x382B "BAM_P_EVNT_GEN_TRSHLD2 (at 0xF9A47828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES2"
        group.long 0x3820--0x3823 "BAM_P_FIFO_SIZES2 (at 0xF9A47820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_2"
        group.long 0x3834--0x3837 "BAM_P_RETR_CNTXT_2 (at 0xF9A47834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_2"
        group.long 0x3838--0x383B "BAM_P_SI_CNTXT_2 (at 0xF9A47838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_2"
        group.long 0x3830--0x3833 "BAM_P_DF_CNTXT_2 (at 0xF9A47830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_2"
        group.long 0x3804--0x3807 "BAM_P_AU_PSM_CNTXT_1_2 (at 0xF9A47804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_2"
        group.long 0x3808--0x380B "BAM_P_PSM_CNTXT_2_2 (at 0xF9A47808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_2"
        group.long 0x380C--0x380F "BAM_P_PSM_CNTXT_3_2 (at 0xF9A4780C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_2"
        group.long 0x3810--0x3813 "BAM_P_PSM_CNTXT_4_2 (at 0xF9A47810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_2"
        group.long 0x3814--0x3817 "BAM_P_PSM_CNTXT_5_2 (at 0xF9A47814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 2
tree.end
tree "Pipe 3"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL3"
        group.long 0x4000--0x4003 "BAM_P_CTRL3 (at 0xF9A48000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST3"
        group.long 0x4004--0x4007 "BAM_P_RST3 (at 0xF9A48004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT3"
        group.long 0x4008--0x400B "BAM_P_HALT3 (at 0xF9A48008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG3"
        group.long 0x4030--0x4033 "BAM_P_TRUST_REG3 (at 0xF9A48030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS3"
        group.long 0x4010--0x4013 "BAM_P_IRQ_STTS3 (at 0xF9A48010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR3"
        group.long 0x4014--0x4017 "BAM_P_IRQ_CLR3 (at 0xF9A48014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN3"
        group.long 0x4018--0x401B "BAM_P_IRQ_EN3 (at 0xF9A48018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER3"
        group.long 0x401C--0x401F "BAM_P_TIMER3 (at 0xF9A4801C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL3"
        group.long 0x4020--0x4023 "BAM_P_TIMER_CTRL3 (at 0xF9A48020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND3"
        group.long 0x4024--0x4027 "BAM_P_PRDCR_SDBND3 (at 0xF9A48024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND3"
        group.long 0x4028--0x402B "BAM_P_CNSMR_SDBND3 (at 0xF9A48028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR3"
        group.long 0x482C--0x482F "BAM_P_EVNT_DEST_ADDR3 (at 0xF9A4882C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG3"
        group.long 0x4818--0x481B "BAM_P_EVNT_REG3 (at 0xF9A48818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS3"
        group.long 0x4800--0x4803 "BAM_P_SW_OFSTS3 (at 0xF9A48800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR3"
        group.long 0x4824--0x4827 "BAM_P_DATA_FIFO_ADDR3 (at 0xF9A48824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR3"
        group.long 0x481C--0x481F "BAM_P_DESC_FIFO_ADDR3 (at 0xF9A4881C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD3"
        group.long 0x4828--0x482B "BAM_P_EVNT_GEN_TRSHLD3 (at 0xF9A48828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES3"
        group.long 0x4820--0x4823 "BAM_P_FIFO_SIZES3 (at 0xF9A48820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_3"
        group.long 0x4834--0x4837 "BAM_P_RETR_CNTXT_3 (at 0xF9A48834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_3"
        group.long 0x4838--0x483B "BAM_P_SI_CNTXT_3 (at 0xF9A48838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_3"
        group.long 0x4830--0x4833 "BAM_P_DF_CNTXT_3 (at 0xF9A48830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_3"
        group.long 0x4804--0x4807 "BAM_P_AU_PSM_CNTXT_1_3 (at 0xF9A48804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_3"
        group.long 0x4808--0x480B "BAM_P_PSM_CNTXT_2_3 (at 0xF9A48808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_3"
        group.long 0x480C--0x480F "BAM_P_PSM_CNTXT_3_3 (at 0xF9A4880C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_3"
        group.long 0x4810--0x4813 "BAM_P_PSM_CNTXT_4_3 (at 0xF9A48810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_3"
        group.long 0x4814--0x4817 "BAM_P_PSM_CNTXT_5_3 (at 0xF9A48814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 3
tree.end
tree "Pipe 4"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL4"
        group.long 0x5000--0x5003 "BAM_P_CTRL4 (at 0xF9A49000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST4"
        group.long 0x5004--0x5007 "BAM_P_RST4 (at 0xF9A49004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT4"
        group.long 0x5008--0x500B "BAM_P_HALT4 (at 0xF9A49008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG4"
        group.long 0x5030--0x5033 "BAM_P_TRUST_REG4 (at 0xF9A49030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS4"
        group.long 0x5010--0x5013 "BAM_P_IRQ_STTS4 (at 0xF9A49010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR4"
        group.long 0x5014--0x5017 "BAM_P_IRQ_CLR4 (at 0xF9A49014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN4"
        group.long 0x5018--0x501B "BAM_P_IRQ_EN4 (at 0xF9A49018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER4"
        group.long 0x501C--0x501F "BAM_P_TIMER4 (at 0xF9A4901C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL4"
        group.long 0x5020--0x5023 "BAM_P_TIMER_CTRL4 (at 0xF9A49020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND4"
        group.long 0x5024--0x5027 "BAM_P_PRDCR_SDBND4 (at 0xF9A49024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND4"
        group.long 0x5028--0x502B "BAM_P_CNSMR_SDBND4 (at 0xF9A49028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR4"
        group.long 0x582C--0x582F "BAM_P_EVNT_DEST_ADDR4 (at 0xF9A4982C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG4"
        group.long 0x5818--0x581B "BAM_P_EVNT_REG4 (at 0xF9A49818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS4"
        group.long 0x5800--0x5803 "BAM_P_SW_OFSTS4 (at 0xF9A49800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR4"
        group.long 0x5824--0x5827 "BAM_P_DATA_FIFO_ADDR4 (at 0xF9A49824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR4"
        group.long 0x581C--0x581F "BAM_P_DESC_FIFO_ADDR4 (at 0xF9A4981C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD4"
        group.long 0x5828--0x582B "BAM_P_EVNT_GEN_TRSHLD4 (at 0xF9A49828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES4"
        group.long 0x5820--0x5823 "BAM_P_FIFO_SIZES4 (at 0xF9A49820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_4"
        group.long 0x5834--0x5837 "BAM_P_RETR_CNTXT_4 (at 0xF9A49834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_4"
        group.long 0x5838--0x583B "BAM_P_SI_CNTXT_4 (at 0xF9A49838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_4"
        group.long 0x5830--0x5833 "BAM_P_DF_CNTXT_4 (at 0xF9A49830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_4"
        group.long 0x5804--0x5807 "BAM_P_AU_PSM_CNTXT_1_4 (at 0xF9A49804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_4"
        group.long 0x5808--0x580B "BAM_P_PSM_CNTXT_2_4 (at 0xF9A49808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_4"
        group.long 0x580C--0x580F "BAM_P_PSM_CNTXT_3_4 (at 0xF9A4980C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_4"
        group.long 0x5810--0x5813 "BAM_P_PSM_CNTXT_4_4 (at 0xF9A49810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_4"
        group.long 0x5814--0x5817 "BAM_P_PSM_CNTXT_5_4 (at 0xF9A49814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 4
tree.end
tree "Pipe 5"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL5"
        group.long 0x6000--0x6003 "BAM_P_CTRL5 (at 0xF9A4A000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST5"
        group.long 0x6004--0x6007 "BAM_P_RST5 (at 0xF9A4A004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT5"
        group.long 0x6008--0x600B "BAM_P_HALT5 (at 0xF9A4A008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG5"
        group.long 0x6030--0x6033 "BAM_P_TRUST_REG5 (at 0xF9A4A030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS5"
        group.long 0x6010--0x6013 "BAM_P_IRQ_STTS5 (at 0xF9A4A010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR5"
        group.long 0x6014--0x6017 "BAM_P_IRQ_CLR5 (at 0xF9A4A014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN5"
        group.long 0x6018--0x601B "BAM_P_IRQ_EN5 (at 0xF9A4A018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER5"
        group.long 0x601C--0x601F "BAM_P_TIMER5 (at 0xF9A4A01C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL5"
        group.long 0x6020--0x6023 "BAM_P_TIMER_CTRL5 (at 0xF9A4A020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND5"
        group.long 0x6024--0x6027 "BAM_P_PRDCR_SDBND5 (at 0xF9A4A024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND5"
        group.long 0x6028--0x602B "BAM_P_CNSMR_SDBND5 (at 0xF9A4A028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR5"
        group.long 0x682C--0x682F "BAM_P_EVNT_DEST_ADDR5 (at 0xF9A4A82C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG5"
        group.long 0x6818--0x681B "BAM_P_EVNT_REG5 (at 0xF9A4A818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS5"
        group.long 0x6800--0x6803 "BAM_P_SW_OFSTS5 (at 0xF9A4A800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR5"
        group.long 0x6824--0x6827 "BAM_P_DATA_FIFO_ADDR5 (at 0xF9A4A824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR5"
        group.long 0x681C--0x681F "BAM_P_DESC_FIFO_ADDR5 (at 0xF9A4A81C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD5"
        group.long 0x6828--0x682B "BAM_P_EVNT_GEN_TRSHLD5 (at 0xF9A4A828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES5"
        group.long 0x6820--0x6823 "BAM_P_FIFO_SIZES5 (at 0xF9A4A820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_5"
        group.long 0x6834--0x6837 "BAM_P_RETR_CNTXT_5 (at 0xF9A4A834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_5"
        group.long 0x6838--0x683B "BAM_P_SI_CNTXT_5 (at 0xF9A4A838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_5"
        group.long 0x6830--0x6833 "BAM_P_DF_CNTXT_5 (at 0xF9A4A830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_5"
        group.long 0x6804--0x6807 "BAM_P_AU_PSM_CNTXT_1_5 (at 0xF9A4A804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_5"
        group.long 0x6808--0x680B "BAM_P_PSM_CNTXT_2_5 (at 0xF9A4A808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_5"
        group.long 0x680C--0x680F "BAM_P_PSM_CNTXT_3_5 (at 0xF9A4A80C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_5"
        group.long 0x6810--0x6813 "BAM_P_PSM_CNTXT_4_5 (at 0xF9A4A810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_5"
        group.long 0x6814--0x6817 "BAM_P_PSM_CNTXT_5_5 (at 0xF9A4A814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 5
tree.end
tree "Pipe 6"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL6"
        group.long 0x7000--0x7003 "BAM_P_CTRL6 (at 0xF9A4B000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST6"
        group.long 0x7004--0x7007 "BAM_P_RST6 (at 0xF9A4B004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT6"
        group.long 0x7008--0x700B "BAM_P_HALT6 (at 0xF9A4B008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG6"
        group.long 0x7030--0x7033 "BAM_P_TRUST_REG6 (at 0xF9A4B030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS6"
        group.long 0x7010--0x7013 "BAM_P_IRQ_STTS6 (at 0xF9A4B010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR6"
        group.long 0x7014--0x7017 "BAM_P_IRQ_CLR6 (at 0xF9A4B014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN6"
        group.long 0x7018--0x701B "BAM_P_IRQ_EN6 (at 0xF9A4B018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER6"
        group.long 0x701C--0x701F "BAM_P_TIMER6 (at 0xF9A4B01C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL6"
        group.long 0x7020--0x7023 "BAM_P_TIMER_CTRL6 (at 0xF9A4B020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND6"
        group.long 0x7024--0x7027 "BAM_P_PRDCR_SDBND6 (at 0xF9A4B024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND6"
        group.long 0x7028--0x702B "BAM_P_CNSMR_SDBND6 (at 0xF9A4B028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR6"
        group.long 0x782C--0x782F "BAM_P_EVNT_DEST_ADDR6 (at 0xF9A4B82C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG6"
        group.long 0x7818--0x781B "BAM_P_EVNT_REG6 (at 0xF9A4B818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS6"
        group.long 0x7800--0x7803 "BAM_P_SW_OFSTS6 (at 0xF9A4B800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR6"
        group.long 0x7824--0x7827 "BAM_P_DATA_FIFO_ADDR6 (at 0xF9A4B824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR6"
        group.long 0x781C--0x781F "BAM_P_DESC_FIFO_ADDR6 (at 0xF9A4B81C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD6"
        group.long 0x7828--0x782B "BAM_P_EVNT_GEN_TRSHLD6 (at 0xF9A4B828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES6"
        group.long 0x7820--0x7823 "BAM_P_FIFO_SIZES6 (at 0xF9A4B820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_6"
        group.long 0x7834--0x7837 "BAM_P_RETR_CNTXT_6 (at 0xF9A4B834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_6"
        group.long 0x7838--0x783B "BAM_P_SI_CNTXT_6 (at 0xF9A4B838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_6"
        group.long 0x7830--0x7833 "BAM_P_DF_CNTXT_6 (at 0xF9A4B830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_6"
        group.long 0x7804--0x7807 "BAM_P_AU_PSM_CNTXT_1_6 (at 0xF9A4B804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_6"
        group.long 0x7808--0x780B "BAM_P_PSM_CNTXT_2_6 (at 0xF9A4B808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_6"
        group.long 0x780C--0x780F "BAM_P_PSM_CNTXT_3_6 (at 0xF9A4B80C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_6"
        group.long 0x7810--0x7813 "BAM_P_PSM_CNTXT_4_6 (at 0xF9A4B810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_6"
        group.long 0x7814--0x7817 "BAM_P_PSM_CNTXT_5_6 (at 0xF9A4B814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 6
tree.end
tree "Pipe 7"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL7"
        group.long 0x8000--0x8003 "BAM_P_CTRL7 (at 0xF9A4C000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST7"
        group.long 0x8004--0x8007 "BAM_P_RST7 (at 0xF9A4C004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT7"
        group.long 0x8008--0x800B "BAM_P_HALT7 (at 0xF9A4C008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG7"
        group.long 0x8030--0x8033 "BAM_P_TRUST_REG7 (at 0xF9A4C030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS7"
        group.long 0x8010--0x8013 "BAM_P_IRQ_STTS7 (at 0xF9A4C010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR7"
        group.long 0x8014--0x8017 "BAM_P_IRQ_CLR7 (at 0xF9A4C014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN7"
        group.long 0x8018--0x801B "BAM_P_IRQ_EN7 (at 0xF9A4C018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER7"
        group.long 0x801C--0x801F "BAM_P_TIMER7 (at 0xF9A4C01C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL7"
        group.long 0x8020--0x8023 "BAM_P_TIMER_CTRL7 (at 0xF9A4C020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND7"
        group.long 0x8024--0x8027 "BAM_P_PRDCR_SDBND7 (at 0xF9A4C024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND7"
        group.long 0x8028--0x802B "BAM_P_CNSMR_SDBND7 (at 0xF9A4C028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR7"
        group.long 0x882C--0x882F "BAM_P_EVNT_DEST_ADDR7 (at 0xF9A4C82C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG7"
        group.long 0x8818--0x881B "BAM_P_EVNT_REG7 (at 0xF9A4C818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS7"
        group.long 0x8800--0x8803 "BAM_P_SW_OFSTS7 (at 0xF9A4C800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR7"
        group.long 0x8824--0x8827 "BAM_P_DATA_FIFO_ADDR7 (at 0xF9A4C824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR7"
        group.long 0x881C--0x881F "BAM_P_DESC_FIFO_ADDR7 (at 0xF9A4C81C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD7"
        group.long 0x8828--0x882B "BAM_P_EVNT_GEN_TRSHLD7 (at 0xF9A4C828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES7"
        group.long 0x8820--0x8823 "BAM_P_FIFO_SIZES7 (at 0xF9A4C820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_7"
        group.long 0x8834--0x8837 "BAM_P_RETR_CNTXT_7 (at 0xF9A4C834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_7"
        group.long 0x8838--0x883B "BAM_P_SI_CNTXT_7 (at 0xF9A4C838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_7"
        group.long 0x8830--0x8833 "BAM_P_DF_CNTXT_7 (at 0xF9A4C830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_7"
        group.long 0x8804--0x8807 "BAM_P_AU_PSM_CNTXT_1_7 (at 0xF9A4C804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_7"
        group.long 0x8808--0x880B "BAM_P_PSM_CNTXT_2_7 (at 0xF9A4C808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_7"
        group.long 0x880C--0x880F "BAM_P_PSM_CNTXT_3_7 (at 0xF9A4C80C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_7"
        group.long 0x8810--0x8813 "BAM_P_PSM_CNTXT_4_7 (at 0xF9A4C810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_7"
        group.long 0x8814--0x8817 "BAM_P_PSM_CNTXT_5_7 (at 0xF9A4C814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 7
tree.end
tree "Pipe 8"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL8"
        group.long 0x9000--0x9003 "BAM_P_CTRL8 (at 0xF9A4D000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST8"
        group.long 0x9004--0x9007 "BAM_P_RST8 (at 0xF9A4D004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT8"
        group.long 0x9008--0x900B "BAM_P_HALT8 (at 0xF9A4D008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG8"
        group.long 0x9030--0x9033 "BAM_P_TRUST_REG8 (at 0xF9A4D030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS8"
        group.long 0x9010--0x9013 "BAM_P_IRQ_STTS8 (at 0xF9A4D010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR8"
        group.long 0x9014--0x9017 "BAM_P_IRQ_CLR8 (at 0xF9A4D014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN8"
        group.long 0x9018--0x901B "BAM_P_IRQ_EN8 (at 0xF9A4D018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER8"
        group.long 0x901C--0x901F "BAM_P_TIMER8 (at 0xF9A4D01C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL8"
        group.long 0x9020--0x9023 "BAM_P_TIMER_CTRL8 (at 0xF9A4D020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND8"
        group.long 0x9024--0x9027 "BAM_P_PRDCR_SDBND8 (at 0xF9A4D024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND8"
        group.long 0x9028--0x902B "BAM_P_CNSMR_SDBND8 (at 0xF9A4D028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR8"
        group.long 0x982C--0x982F "BAM_P_EVNT_DEST_ADDR8 (at 0xF9A4D82C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG8"
        group.long 0x9818--0x981B "BAM_P_EVNT_REG8 (at 0xF9A4D818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS8"
        group.long 0x9800--0x9803 "BAM_P_SW_OFSTS8 (at 0xF9A4D800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR8"
        group.long 0x9824--0x9827 "BAM_P_DATA_FIFO_ADDR8 (at 0xF9A4D824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR8"
        group.long 0x981C--0x981F "BAM_P_DESC_FIFO_ADDR8 (at 0xF9A4D81C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD8"
        group.long 0x9828--0x982B "BAM_P_EVNT_GEN_TRSHLD8 (at 0xF9A4D828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES8"
        group.long 0x9820--0x9823 "BAM_P_FIFO_SIZES8 (at 0xF9A4D820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_8"
        group.long 0x9834--0x9837 "BAM_P_RETR_CNTXT_8 (at 0xF9A4D834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_8"
        group.long 0x9838--0x983B "BAM_P_SI_CNTXT_8 (at 0xF9A4D838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_8"
        group.long 0x9830--0x9833 "BAM_P_DF_CNTXT_8 (at 0xF9A4D830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_8"
        group.long 0x9804--0x9807 "BAM_P_AU_PSM_CNTXT_1_8 (at 0xF9A4D804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_8"
        group.long 0x9808--0x980B "BAM_P_PSM_CNTXT_2_8 (at 0xF9A4D808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_8"
        group.long 0x980C--0x980F "BAM_P_PSM_CNTXT_3_8 (at 0xF9A4D80C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_8"
        group.long 0x9810--0x9813 "BAM_P_PSM_CNTXT_4_8 (at 0xF9A4D810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_8"
        group.long 0x9814--0x9817 "BAM_P_PSM_CNTXT_5_8 (at 0xF9A4D814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 8
tree.end
tree "Pipe 9"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL9"
        group.long 0xA000--0xA003 "BAM_P_CTRL9 (at 0xF9A4E000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST9"
        group.long 0xA004--0xA007 "BAM_P_RST9 (at 0xF9A4E004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT9"
        group.long 0xA008--0xA00B "BAM_P_HALT9 (at 0xF9A4E008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG9"
        group.long 0xA030--0xA033 "BAM_P_TRUST_REG9 (at 0xF9A4E030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS9"
        group.long 0xA010--0xA013 "BAM_P_IRQ_STTS9 (at 0xF9A4E010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR9"
        group.long 0xA014--0xA017 "BAM_P_IRQ_CLR9 (at 0xF9A4E014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN9"
        group.long 0xA018--0xA01B "BAM_P_IRQ_EN9 (at 0xF9A4E018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER9"
        group.long 0xA01C--0xA01F "BAM_P_TIMER9 (at 0xF9A4E01C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL9"
        group.long 0xA020--0xA023 "BAM_P_TIMER_CTRL9 (at 0xF9A4E020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND9"
        group.long 0xA024--0xA027 "BAM_P_PRDCR_SDBND9 (at 0xF9A4E024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND9"
        group.long 0xA028--0xA02B "BAM_P_CNSMR_SDBND9 (at 0xF9A4E028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR9"
        group.long 0xA82C--0xA82F "BAM_P_EVNT_DEST_ADDR9 (at 0xF9A4E82C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG9"
        group.long 0xA818--0xA81B "BAM_P_EVNT_REG9 (at 0xF9A4E818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS9"
        group.long 0xA800--0xA803 "BAM_P_SW_OFSTS9 (at 0xF9A4E800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR9"
        group.long 0xA824--0xA827 "BAM_P_DATA_FIFO_ADDR9 (at 0xF9A4E824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR9"
        group.long 0xA81C--0xA81F "BAM_P_DESC_FIFO_ADDR9 (at 0xF9A4E81C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD9"
        group.long 0xA828--0xA82B "BAM_P_EVNT_GEN_TRSHLD9 (at 0xF9A4E828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES9"
        group.long 0xA820--0xA823 "BAM_P_FIFO_SIZES9 (at 0xF9A4E820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_9"
        group.long 0xA834--0xA837 "BAM_P_RETR_CNTXT_9 (at 0xF9A4E834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_9"
        group.long 0xA838--0xA83B "BAM_P_SI_CNTXT_9 (at 0xF9A4E838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_9"
        group.long 0xA830--0xA833 "BAM_P_DF_CNTXT_9 (at 0xF9A4E830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_9"
        group.long 0xA804--0xA807 "BAM_P_AU_PSM_CNTXT_1_9 (at 0xF9A4E804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_9"
        group.long 0xA808--0xA80B "BAM_P_PSM_CNTXT_2_9 (at 0xF9A4E808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_9"
        group.long 0xA80C--0xA80F "BAM_P_PSM_CNTXT_3_9 (at 0xF9A4E80C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_9"
        group.long 0xA810--0xA813 "BAM_P_PSM_CNTXT_4_9 (at 0xF9A4E810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_9"
        group.long 0xA814--0xA817 "BAM_P_PSM_CNTXT_5_9 (at 0xF9A4E814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 9
tree.end
tree "Pipe 10"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL10"
        group.long 0xB000--0xB003 "BAM_P_CTRL10 (at 0xF9A4F000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST10"
        group.long 0xB004--0xB007 "BAM_P_RST10 (at 0xF9A4F004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT10"
        group.long 0xB008--0xB00B "BAM_P_HALT10 (at 0xF9A4F008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG10"
        group.long 0xB030--0xB033 "BAM_P_TRUST_REG10 (at 0xF9A4F030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS10"
        group.long 0xB010--0xB013 "BAM_P_IRQ_STTS10 (at 0xF9A4F010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR10"
        group.long 0xB014--0xB017 "BAM_P_IRQ_CLR10 (at 0xF9A4F014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN10"
        group.long 0xB018--0xB01B "BAM_P_IRQ_EN10 (at 0xF9A4F018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER10"
        group.long 0xB01C--0xB01F "BAM_P_TIMER10 (at 0xF9A4F01C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL10"
        group.long 0xB020--0xB023 "BAM_P_TIMER_CTRL10 (at 0xF9A4F020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND10"
        group.long 0xB024--0xB027 "BAM_P_PRDCR_SDBND10 (at 0xF9A4F024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND10"
        group.long 0xB028--0xB02B "BAM_P_CNSMR_SDBND10 (at 0xF9A4F028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR10"
        group.long 0xB82C--0xB82F "BAM_P_EVNT_DEST_ADDR10 (at 0xF9A4F82C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG10"
        group.long 0xB818--0xB81B "BAM_P_EVNT_REG10 (at 0xF9A4F818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS10"
        group.long 0xB800--0xB803 "BAM_P_SW_OFSTS10 (at 0xF9A4F800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR10"
        group.long 0xB824--0xB827 "BAM_P_DATA_FIFO_ADDR10 (at 0xF9A4F824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR10"
        group.long 0xB81C--0xB81F "BAM_P_DESC_FIFO_ADDR10 (at 0xF9A4F81C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD10"
        group.long 0xB828--0xB82B "BAM_P_EVNT_GEN_TRSHLD10 (at 0xF9A4F828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES10"
        group.long 0xB820--0xB823 "BAM_P_FIFO_SIZES10 (at 0xF9A4F820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_10"
        group.long 0xB834--0xB837 "BAM_P_RETR_CNTXT_10 (at 0xF9A4F834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_10"
        group.long 0xB838--0xB83B "BAM_P_SI_CNTXT_10 (at 0xF9A4F838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_10"
        group.long 0xB830--0xB833 "BAM_P_DF_CNTXT_10 (at 0xF9A4F830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_10"
        group.long 0xB804--0xB807 "BAM_P_AU_PSM_CNTXT_1_10 (at 0xF9A4F804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_10"
        group.long 0xB808--0xB80B "BAM_P_PSM_CNTXT_2_10 (at 0xF9A4F808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_10"
        group.long 0xB80C--0xB80F "BAM_P_PSM_CNTXT_3_10 (at 0xF9A4F80C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_10"
        group.long 0xB810--0xB813 "BAM_P_PSM_CNTXT_4_10 (at 0xF9A4F810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_10"
        group.long 0xB814--0xB817 "BAM_P_PSM_CNTXT_5_10 (at 0xF9A4F814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 10
tree.end
tree "Pipe 11"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL11"
        group.long 0xC000--0xC003 "BAM_P_CTRL11 (at 0xF9A50000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST11"
        group.long 0xC004--0xC007 "BAM_P_RST11 (at 0xF9A50004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT11"
        group.long 0xC008--0xC00B "BAM_P_HALT11 (at 0xF9A50008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG11"
        group.long 0xC030--0xC033 "BAM_P_TRUST_REG11 (at 0xF9A50030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS11"
        group.long 0xC010--0xC013 "BAM_P_IRQ_STTS11 (at 0xF9A50010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR11"
        group.long 0xC014--0xC017 "BAM_P_IRQ_CLR11 (at 0xF9A50014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN11"
        group.long 0xC018--0xC01B "BAM_P_IRQ_EN11 (at 0xF9A50018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER11"
        group.long 0xC01C--0xC01F "BAM_P_TIMER11 (at 0xF9A5001C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL11"
        group.long 0xC020--0xC023 "BAM_P_TIMER_CTRL11 (at 0xF9A50020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND11"
        group.long 0xC024--0xC027 "BAM_P_PRDCR_SDBND11 (at 0xF9A50024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND11"
        group.long 0xC028--0xC02B "BAM_P_CNSMR_SDBND11 (at 0xF9A50028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR11"
        group.long 0xC82C--0xC82F "BAM_P_EVNT_DEST_ADDR11 (at 0xF9A5082C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG11"
        group.long 0xC818--0xC81B "BAM_P_EVNT_REG11 (at 0xF9A50818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS11"
        group.long 0xC800--0xC803 "BAM_P_SW_OFSTS11 (at 0xF9A50800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR11"
        group.long 0xC824--0xC827 "BAM_P_DATA_FIFO_ADDR11 (at 0xF9A50824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR11"
        group.long 0xC81C--0xC81F "BAM_P_DESC_FIFO_ADDR11 (at 0xF9A5081C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD11"
        group.long 0xC828--0xC82B "BAM_P_EVNT_GEN_TRSHLD11 (at 0xF9A50828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES11"
        group.long 0xC820--0xC823 "BAM_P_FIFO_SIZES11 (at 0xF9A50820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_11"
        group.long 0xC834--0xC837 "BAM_P_RETR_CNTXT_11 (at 0xF9A50834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_11"
        group.long 0xC838--0xC83B "BAM_P_SI_CNTXT_11 (at 0xF9A50838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_11"
        group.long 0xC830--0xC833 "BAM_P_DF_CNTXT_11 (at 0xF9A50830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_11"
        group.long 0xC804--0xC807 "BAM_P_AU_PSM_CNTXT_1_11 (at 0xF9A50804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_11"
        group.long 0xC808--0xC80B "BAM_P_PSM_CNTXT_2_11 (at 0xF9A50808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_11"
        group.long 0xC80C--0xC80F "BAM_P_PSM_CNTXT_3_11 (at 0xF9A5080C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_11"
        group.long 0xC810--0xC813 "BAM_P_PSM_CNTXT_4_11 (at 0xF9A50810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_11"
        group.long 0xC814--0xC817 "BAM_P_PSM_CNTXT_5_11 (at 0xF9A50814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 11
tree.end
tree "Pipe 12"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL12"
        group.long 0xD000--0xD003 "BAM_P_CTRL12 (at 0xF9A51000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST12"
        group.long 0xD004--0xD007 "BAM_P_RST12 (at 0xF9A51004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT12"
        group.long 0xD008--0xD00B "BAM_P_HALT12 (at 0xF9A51008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG12"
        group.long 0xD030--0xD033 "BAM_P_TRUST_REG12 (at 0xF9A51030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS12"
        group.long 0xD010--0xD013 "BAM_P_IRQ_STTS12 (at 0xF9A51010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR12"
        group.long 0xD014--0xD017 "BAM_P_IRQ_CLR12 (at 0xF9A51014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN12"
        group.long 0xD018--0xD01B "BAM_P_IRQ_EN12 (at 0xF9A51018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER12"
        group.long 0xD01C--0xD01F "BAM_P_TIMER12 (at 0xF9A5101C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL12"
        group.long 0xD020--0xD023 "BAM_P_TIMER_CTRL12 (at 0xF9A51020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND12"
        group.long 0xD024--0xD027 "BAM_P_PRDCR_SDBND12 (at 0xF9A51024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND12"
        group.long 0xD028--0xD02B "BAM_P_CNSMR_SDBND12 (at 0xF9A51028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR12"
        group.long 0xD82C--0xD82F "BAM_P_EVNT_DEST_ADDR12 (at 0xF9A5182C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG12"
        group.long 0xD818--0xD81B "BAM_P_EVNT_REG12 (at 0xF9A51818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS12"
        group.long 0xD800--0xD803 "BAM_P_SW_OFSTS12 (at 0xF9A51800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR12"
        group.long 0xD824--0xD827 "BAM_P_DATA_FIFO_ADDR12 (at 0xF9A51824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR12"
        group.long 0xD81C--0xD81F "BAM_P_DESC_FIFO_ADDR12 (at 0xF9A5181C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD12"
        group.long 0xD828--0xD82B "BAM_P_EVNT_GEN_TRSHLD12 (at 0xF9A51828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES12"
        group.long 0xD820--0xD823 "BAM_P_FIFO_SIZES12 (at 0xF9A51820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_12"
        group.long 0xD834--0xD837 "BAM_P_RETR_CNTXT_12 (at 0xF9A51834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_12"
        group.long 0xD838--0xD83B "BAM_P_SI_CNTXT_12 (at 0xF9A51838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_12"
        group.long 0xD830--0xD833 "BAM_P_DF_CNTXT_12 (at 0xF9A51830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_12"
        group.long 0xD804--0xD807 "BAM_P_AU_PSM_CNTXT_1_12 (at 0xF9A51804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_12"
        group.long 0xD808--0xD80B "BAM_P_PSM_CNTXT_2_12 (at 0xF9A51808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_12"
        group.long 0xD80C--0xD80F "BAM_P_PSM_CNTXT_3_12 (at 0xF9A5180C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_12"
        group.long 0xD810--0xD813 "BAM_P_PSM_CNTXT_4_12 (at 0xF9A51810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_12"
        group.long 0xD814--0xD817 "BAM_P_PSM_CNTXT_5_12 (at 0xF9A51814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 12
tree.end
tree "Pipe 13"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL13"
        group.long 0xE000--0xE003 "BAM_P_CTRL13 (at 0xF9A52000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST13"
        group.long 0xE004--0xE007 "BAM_P_RST13 (at 0xF9A52004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT13"
        group.long 0xE008--0xE00B "BAM_P_HALT13 (at 0xF9A52008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG13"
        group.long 0xE030--0xE033 "BAM_P_TRUST_REG13 (at 0xF9A52030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS13"
        group.long 0xE010--0xE013 "BAM_P_IRQ_STTS13 (at 0xF9A52010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR13"
        group.long 0xE014--0xE017 "BAM_P_IRQ_CLR13 (at 0xF9A52014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN13"
        group.long 0xE018--0xE01B "BAM_P_IRQ_EN13 (at 0xF9A52018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER13"
        group.long 0xE01C--0xE01F "BAM_P_TIMER13 (at 0xF9A5201C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL13"
        group.long 0xE020--0xE023 "BAM_P_TIMER_CTRL13 (at 0xF9A52020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND13"
        group.long 0xE024--0xE027 "BAM_P_PRDCR_SDBND13 (at 0xF9A52024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND13"
        group.long 0xE028--0xE02B "BAM_P_CNSMR_SDBND13 (at 0xF9A52028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR13"
        group.long 0xE82C--0xE82F "BAM_P_EVNT_DEST_ADDR13 (at 0xF9A5282C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG13"
        group.long 0xE818--0xE81B "BAM_P_EVNT_REG13 (at 0xF9A52818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS13"
        group.long 0xE800--0xE803 "BAM_P_SW_OFSTS13 (at 0xF9A52800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR13"
        group.long 0xE824--0xE827 "BAM_P_DATA_FIFO_ADDR13 (at 0xF9A52824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR13"
        group.long 0xE81C--0xE81F "BAM_P_DESC_FIFO_ADDR13 (at 0xF9A5281C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD13"
        group.long 0xE828--0xE82B "BAM_P_EVNT_GEN_TRSHLD13 (at 0xF9A52828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES13"
        group.long 0xE820--0xE823 "BAM_P_FIFO_SIZES13 (at 0xF9A52820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_13"
        group.long 0xE834--0xE837 "BAM_P_RETR_CNTXT_13 (at 0xF9A52834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_13"
        group.long 0xE838--0xE83B "BAM_P_SI_CNTXT_13 (at 0xF9A52838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_13"
        group.long 0xE830--0xE833 "BAM_P_DF_CNTXT_13 (at 0xF9A52830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_13"
        group.long 0xE804--0xE807 "BAM_P_AU_PSM_CNTXT_1_13 (at 0xF9A52804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_13"
        group.long 0xE808--0xE80B "BAM_P_PSM_CNTXT_2_13 (at 0xF9A52808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_13"
        group.long 0xE80C--0xE80F "BAM_P_PSM_CNTXT_3_13 (at 0xF9A5280C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_13"
        group.long 0xE810--0xE813 "BAM_P_PSM_CNTXT_4_13 (at 0xF9A52810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_13"
        group.long 0xE814--0xE817 "BAM_P_PSM_CNTXT_5_13 (at 0xF9A52814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 13
tree.end
tree "Pipe 14"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL14"
        group.long 0xF000--0xF003 "BAM_P_CTRL14 (at 0xF9A53000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST14"
        group.long 0xF004--0xF007 "BAM_P_RST14 (at 0xF9A53004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT14"
        group.long 0xF008--0xF00B "BAM_P_HALT14 (at 0xF9A53008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG14"
        group.long 0xF030--0xF033 "BAM_P_TRUST_REG14 (at 0xF9A53030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS14"
        group.long 0xF010--0xF013 "BAM_P_IRQ_STTS14 (at 0xF9A53010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR14"
        group.long 0xF014--0xF017 "BAM_P_IRQ_CLR14 (at 0xF9A53014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN14"
        group.long 0xF018--0xF01B "BAM_P_IRQ_EN14 (at 0xF9A53018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER14"
        group.long 0xF01C--0xF01F "BAM_P_TIMER14 (at 0xF9A5301C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL14"
        group.long 0xF020--0xF023 "BAM_P_TIMER_CTRL14 (at 0xF9A53020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND14"
        group.long 0xF024--0xF027 "BAM_P_PRDCR_SDBND14 (at 0xF9A53024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND14"
        group.long 0xF028--0xF02B "BAM_P_CNSMR_SDBND14 (at 0xF9A53028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR14"
        group.long 0xF82C--0xF82F "BAM_P_EVNT_DEST_ADDR14 (at 0xF9A5382C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG14"
        group.long 0xF818--0xF81B "BAM_P_EVNT_REG14 (at 0xF9A53818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS14"
        group.long 0xF800--0xF803 "BAM_P_SW_OFSTS14 (at 0xF9A53800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR14"
        group.long 0xF824--0xF827 "BAM_P_DATA_FIFO_ADDR14 (at 0xF9A53824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR14"
        group.long 0xF81C--0xF81F "BAM_P_DESC_FIFO_ADDR14 (at 0xF9A5381C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD14"
        group.long 0xF828--0xF82B "BAM_P_EVNT_GEN_TRSHLD14 (at 0xF9A53828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES14"
        group.long 0xF820--0xF823 "BAM_P_FIFO_SIZES14 (at 0xF9A53820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_14"
        group.long 0xF834--0xF837 "BAM_P_RETR_CNTXT_14 (at 0xF9A53834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_14"
        group.long 0xF838--0xF83B "BAM_P_SI_CNTXT_14 (at 0xF9A53838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_14"
        group.long 0xF830--0xF833 "BAM_P_DF_CNTXT_14 (at 0xF9A53830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_14"
        group.long 0xF804--0xF807 "BAM_P_AU_PSM_CNTXT_1_14 (at 0xF9A53804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_14"
        group.long 0xF808--0xF80B "BAM_P_PSM_CNTXT_2_14 (at 0xF9A53808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_14"
        group.long 0xF80C--0xF80F "BAM_P_PSM_CNTXT_3_14 (at 0xF9A5380C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_14"
        group.long 0xF810--0xF813 "BAM_P_PSM_CNTXT_4_14 (at 0xF9A53810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_14"
        group.long 0xF814--0xF817 "BAM_P_PSM_CNTXT_5_14 (at 0xF9A53814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 14
tree.end
tree "Pipe 15"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL15"
        group.long 0x10000--0x10003 "BAM_P_CTRL15 (at 0xF9A54000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST15"
        group.long 0x10004--0x10007 "BAM_P_RST15 (at 0xF9A54004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT15"
        group.long 0x10008--0x1000B "BAM_P_HALT15 (at 0xF9A54008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG15"
        group.long 0x10030--0x10033 "BAM_P_TRUST_REG15 (at 0xF9A54030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS15"
        group.long 0x10010--0x10013 "BAM_P_IRQ_STTS15 (at 0xF9A54010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR15"
        group.long 0x10014--0x10017 "BAM_P_IRQ_CLR15 (at 0xF9A54014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN15"
        group.long 0x10018--0x1001B "BAM_P_IRQ_EN15 (at 0xF9A54018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER15"
        group.long 0x1001C--0x1001F "BAM_P_TIMER15 (at 0xF9A5401C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL15"
        group.long 0x10020--0x10023 "BAM_P_TIMER_CTRL15 (at 0xF9A54020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND15"
        group.long 0x10024--0x10027 "BAM_P_PRDCR_SDBND15 (at 0xF9A54024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND15"
        group.long 0x10028--0x1002B "BAM_P_CNSMR_SDBND15 (at 0xF9A54028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR15"
        group.long 0x1082C--0x1082F "BAM_P_EVNT_DEST_ADDR15 (at 0xF9A5482C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG15"
        group.long 0x10818--0x1081B "BAM_P_EVNT_REG15 (at 0xF9A54818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS15"
        group.long 0x10800--0x10803 "BAM_P_SW_OFSTS15 (at 0xF9A54800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR15"
        group.long 0x10824--0x10827 "BAM_P_DATA_FIFO_ADDR15 (at 0xF9A54824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR15"
        group.long 0x1081C--0x1081F "BAM_P_DESC_FIFO_ADDR15 (at 0xF9A5481C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD15"
        group.long 0x10828--0x1082B "BAM_P_EVNT_GEN_TRSHLD15 (at 0xF9A54828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES15"
        group.long 0x10820--0x10823 "BAM_P_FIFO_SIZES15 (at 0xF9A54820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_15"
        group.long 0x10834--0x10837 "BAM_P_RETR_CNTXT_15 (at 0xF9A54834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_15"
        group.long 0x10838--0x1083B "BAM_P_SI_CNTXT_15 (at 0xF9A54838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_15"
        group.long 0x10830--0x10833 "BAM_P_DF_CNTXT_15 (at 0xF9A54830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_15"
        group.long 0x10804--0x10807 "BAM_P_AU_PSM_CNTXT_1_15 (at 0xF9A54804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_15"
        group.long 0x10808--0x1080B "BAM_P_PSM_CNTXT_2_15 (at 0xF9A54808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_15"
        group.long 0x1080C--0x1080F "BAM_P_PSM_CNTXT_3_15 (at 0xF9A5480C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_15"
        group.long 0x10810--0x10813 "BAM_P_PSM_CNTXT_4_15 (at 0xF9A54810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_15"
        group.long 0x10814--0x10817 "BAM_P_PSM_CNTXT_5_15 (at 0xF9A54814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 15
tree.end
tree.end
;Block Per Data Ends

base ad:0xFC37C000
tree "QDSS"
tree "BAM Control Registers"
      tree "BAM_CTRL"
        group.long 0x0--0x3 "BAM_CTRL (at 0xFC37C000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x13 " [   19]   CACHE_MISS_ERR_RESP_EN                   = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11--0x12 " [18:17]   LOCAL_CLK_GATING                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   IBC_DISABLE                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0xF " [   15]   BAM_CACHED_DESC_STORE                    = "  "0,1"
        textline ""
        bitfld.long 0x0 0xD--0xE " [14:13]   BAM_DESC_CACHE_SEL                       = "  "0,1,2,3"
        textline ""
        hexmask.long.word 0x0 0x5--0xB 1  " [11:05]   BAM_TESTBUS_SEL                          = " 
        textline ""
        bitfld.long 0x0 0x4 " [   04]   BAM_EN_ACCUM                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_EN                                   = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   BAM_SW_RST                               = "  "0,1"
        textline ""
      tree.end
      tree "BAM_REVISION"
        group.long 0x4--0x7 "BAM_REVISION (at 0xFC37C004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x18--0x1F 1  " [31:24]   INACTIV_TMR_BASE                         = " 
        textline ""
        bitfld.long 0x0 0x17 " [   23]   CMD_DESC_EN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15--0x16 " [22:21]   DESC_CACHE_DEPTH                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   NUM_INACTIV_TMRS                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x13 " [   19]   INACTIV_TMRS_EXST                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x12 " [   18]   HIGH_FREQUENCY_BAM                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11 " [   17]   BAM_HAS_NO_BYPASS                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   SECURED                                  = "  "0,1"
        textline ""
        bitfld.long 0x0 0xF " [   15]   USE_VMIDMT                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0xE " [   14]   AXI_ACTIVE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0xD " [   13]   CE_BUFFER_SIZE                           = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x8--0xB 1  " [11:08]   NUM_EES                                  = " 
        textline ""
        hexmask.long.word 0x0 0x0--0x7 1  " [07:00]   REVISION                                 = " 
        textline ""
      tree.end
      tree "BAM_SW_VERSION"
        group.long 0x80--0x83 "BAM_SW_VERSION (at 0xFC37C080) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x1C--0x1F 1  " [31:28]   MAJOR                                    = " 
        textline ""
        hexmask.long.word 0x0 0x10--0x1B 1  " [27:16]   MINOR                                    = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   STEP                                     = " 
        textline ""
      tree.end
      tree "BAM_NUM_PIPES"
        group.long 0x3C--0x3F "BAM_NUM_PIPES (at 0xFC37C03C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x18--0x1F 1  " [31:24]   BAM_NON_PIPE_GRP                         = " 
        textline ""
        hexmask.long.word 0x0 0x10--0x17 1  " [23:16]   PERIPH_NON_PIPE_GRP                      = " 
        textline ""
        hexmask.long.word 0x0 0x0--0x7 1  " [07:00]   BAM_NUM_PIPES                            = " 
        textline ""
      tree.end
      tree "BAM_TIMER"
        group.long 0x40--0x43 "BAM_TIMER (at 0xFC37C040) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   TIMER                                    = " 
        textline ""
      tree.end
      tree "BAM_TIMER_CTRL"
        group.long 0x44--0x47 "BAM_TIMER_CTRL (at 0xFC37C044) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   TIMER_RST                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   TIMER_RUN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   TIMER_MODE                               = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   TIMER_TRSHLD                             = " 
        textline ""
      tree.end
      tree "BAM_DESC_CNT_TRSHLD"
        group.long 0x8--0xB "BAM_DESC_CNT_TRSHLD (at 0xFC37C008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   CNT_TRSHLD                               = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS"
        group.long 0xC--0xF "BAM_IRQ_SRCS (at 0xFC37C00C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK"
        group.long 0x10--0x13 "BAM_IRQ_SRCS_MSK (at 0xFC37C010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED"
        group.long 0x30--0x33 "BAM_IRQ_SRCS_UNMASKED (at 0xFC37C030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_STTS"
        group.long 0x14--0x17 "BAM_IRQ_STTS (at 0xFC37C014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x4 " [   04]   BAM_TIMER_IRQ                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   BAM_EMPTY_IRQ                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_ERROR_IRQ                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_HRESP_ERR_IRQ                        = "  "0,1"
        textline ""
      tree.end
      tree "BAM_IRQ_CLR"
        group.long 0x18--0x1B "BAM_IRQ_CLR (at 0xFC37C018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x4 " [   04]   BAM_TIMER_CLR                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   BAM_EMPTY_CLR                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_ERROR_CLR                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_HRESP_ERR_CLR                        = "  "0,1"
        textline ""
      tree.end
      tree "BAM_IRQ_EN"
        group.long 0x1C--0x1F "BAM_IRQ_EN (at 0xFC37C01C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x4 " [   04]   BAM_TIMER_EN                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   BAM_EMPTY_EN                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_ERROR_EN                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_HRESP_ERR_EN                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_AHB_MASTER_ERR_CTRLS"
        group.long 0x24--0x27 "BAM_AHB_MASTER_ERR_CTRLS (at 0xFC37C024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x12--0x16 1  " [22:18]   BAM_ERR_HVMID                            = " 
        textline ""
        bitfld.long 0x0 0x11 " [   17]   BAM_ERR_DIRECT_MODE                      = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0xC--0x10 1  " [16:12]   BAM_ERR_HCID                             = " 
        textline ""
        hexmask.long.word 0x0 0x8--0xB 1  " [11:08]   BAM_ERR_HPROT                            = " 
        textline ""
        bitfld.long 0x0 0x5--0x7 " [07:05]   BAM_ERR_HBURST                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x3--0x4 " [04:03]   BAM_ERR_HSIZE                            = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_ERR_HWRITE                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0--0x1 " [01:00]   BAM_ERR_HTRANS                           = "  "0,1,2,3"
        textline ""
      tree.end
      tree "BAM_AHB_MASTER_ERR_ADDR"
        group.long 0x28--0x2B "BAM_AHB_MASTER_ERR_ADDR (at 0xFC37C028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   BAM_ERR_ADDR                             = " 
        textline ""
      tree.end
      tree "BAM_AHB_MASTER_ERR_DATA"
        group.long 0x2C--0x2F "BAM_AHB_MASTER_ERR_DATA (at 0xFC37C02C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   BAM_ERR_DATA                             = " 
        textline ""
      tree.end
      tree "BAM_TRUST_REG"
        group.long 0x70--0x73 "BAM_TRUST_REG (at 0xFC37C070) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0xD " [   13]   LOCK_EE_CTRL                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_VMID                                 = " 
        textline ""
        bitfld.long 0x0 0x7 " [   07]   BAM_RST_BLOCK                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_EE                                   = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_TEST_BUS_SEL"
        group.long 0x74--0x77 "BAM_TEST_BUS_SEL (at 0xFC37C074) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x15 " [   21]   SW_EVENTS_ZERO                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x13--0x14 " [20:19]   SW_EVENTS_SEL                            = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x12 " [   18]   BAM_DATA_ERASE                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11 " [   17]   BAM_DATA_FLUSH                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   BAM_CLK_ALWAYS_ON                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x0--0x6 1  " [06:00]   BAM_TESTBUS_SEL                          = " 
        textline ""
      tree.end
      tree "BAM_TEST_BUS_REG"
        group.long 0x78--0x7B "BAM_TEST_BUS_REG (at 0xFC37C078) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   BAM_TESTBUS_REG                          = " 
        textline ""
      tree.end
      tree "BAM_CNFG_BITS"
        group.long 0x7C--0x7F "BAM_CNFG_BITS (at 0xFC37C07C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1E " [   30]   MULTIPLE_EVENTS_DESC_AVAIL_EN            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   MULTIPLE_EVENTS_SIZE_EN                  = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1C " [   28]   BAM_ZLT_W_CD_SUPPORT                     = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1B " [   27]   BAM_CD_ENABLE                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1A " [   26]   BAM_AU_ACCUMED                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x19 " [   25]   BAM_PSM_P_HD_DATA                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_REG_P_EN                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_WB_DSC_AVL_P_RST                     = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_WB_RETR_SVPNT                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_WB_CSW_ACK_IDL                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_WB_BLK_CSW                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x13 " [   19]   BAM_WB_P_RES                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x12 " [   18]   BAM_SI_P_RES                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11 " [   17]   BAM_AU_P_RES                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   BAM_PSM_P_RES                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0xF " [   15]   BAM_PSM_CSW_REQ                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0xE " [   14]   BAM_SB_CLK_REQ                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0xD " [   13]   BAM_IBC_DISABLE                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0xC " [   12]   BAM_NO_EXT_P_RST                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0xB " [   11]   BAM_FULL_PIPE                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   BAM_ADML_SYNC_BRIDGE                     = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_PIPE_CNFG                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_ADML_DEEP_CONS_FIFO                  = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   BAM_ADML_INCR4_EN_N                      = "  "0,1"
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE0"
        group.long 0x800--0x803 "BAM_IRQ_SRCS_EE0 (at 0xFC37C800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE1"
        group.long 0x880--0x883 "BAM_IRQ_SRCS_EE1 (at 0xFC37C880) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE2"
        group.long 0x900--0x903 "BAM_IRQ_SRCS_EE2 (at 0xFC37C900) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE3"
        group.long 0x980--0x983 "BAM_IRQ_SRCS_EE3 (at 0xFC37C980) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE4"
        group.long 0xA00--0xA03 "BAM_IRQ_SRCS_EE4 (at 0xFC37CA00) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE5"
        group.long 0xA80--0xA83 "BAM_IRQ_SRCS_EE5 (at 0xFC37CA80) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE6"
        group.long 0xB00--0xB03 "BAM_IRQ_SRCS_EE6 (at 0xFC37CB00) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE7"
        group.long 0xB80--0xB83 "BAM_IRQ_SRCS_EE7 (at 0xFC37CB80) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE0"
        group.long 0x804--0x807 "BAM_IRQ_SRCS_MSK_EE0 (at 0xFC37C804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE1"
        group.long 0x884--0x887 "BAM_IRQ_SRCS_MSK_EE1 (at 0xFC37C884) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE2"
        group.long 0x904--0x907 "BAM_IRQ_SRCS_MSK_EE2 (at 0xFC37C904) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE3"
        group.long 0x984--0x987 "BAM_IRQ_SRCS_MSK_EE3 (at 0xFC37C984) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE4"
        group.long 0xA04--0xA07 "BAM_IRQ_SRCS_MSK_EE4 (at 0xFC37CA04) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE5"
        group.long 0xA84--0xA87 "BAM_IRQ_SRCS_MSK_EE5 (at 0xFC37CA84) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE6"
        group.long 0xB04--0xB07 "BAM_IRQ_SRCS_MSK_EE6 (at 0xFC37CB04) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE7"
        group.long 0xB84--0xB87 "BAM_IRQ_SRCS_MSK_EE7 (at 0xFC37CB84) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE0"
        group.long 0x808--0x80B "BAM_IRQ_SRCS_UNMASKED_EE0 (at 0xFC37C808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE1"
        group.long 0x888--0x88B "BAM_IRQ_SRCS_UNMASKED_EE1 (at 0xFC37C888) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE2"
        group.long 0x908--0x90B "BAM_IRQ_SRCS_UNMASKED_EE2 (at 0xFC37C908) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE3"
        group.long 0x988--0x98B "BAM_IRQ_SRCS_UNMASKED_EE3 (at 0xFC37C988) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE4"
        group.long 0xA08--0xA0B "BAM_IRQ_SRCS_UNMASKED_EE4 (at 0xFC37CA08) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE5"
        group.long 0xA88--0xA8B "BAM_IRQ_SRCS_UNMASKED_EE5 (at 0xFC37CA88) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE6"
        group.long 0xB08--0xB0B "BAM_IRQ_SRCS_UNMASKED_EE6 (at 0xFC37CB08) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE7"
        group.long 0xB88--0xB8B "BAM_IRQ_SRCS_UNMASKED_EE7 (at 0xFC37CB88) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
;End of BAM Control Registers
tree.end
tree "Pipe 0"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL0"
        group.long 0x1000--0x1003 "BAM_P_CTRL0 (at 0xFC37D000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST0"
        group.long 0x1004--0x1007 "BAM_P_RST0 (at 0xFC37D004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT0"
        group.long 0x1008--0x100B "BAM_P_HALT0 (at 0xFC37D008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG0"
        group.long 0x1030--0x1033 "BAM_P_TRUST_REG0 (at 0xFC37D030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS0"
        group.long 0x1010--0x1013 "BAM_P_IRQ_STTS0 (at 0xFC37D010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR0"
        group.long 0x1014--0x1017 "BAM_P_IRQ_CLR0 (at 0xFC37D014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN0"
        group.long 0x1018--0x101B "BAM_P_IRQ_EN0 (at 0xFC37D018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER0"
        group.long 0x101C--0x101F "BAM_P_TIMER0 (at 0xFC37D01C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL0"
        group.long 0x1020--0x1023 "BAM_P_TIMER_CTRL0 (at 0xFC37D020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND0"
        group.long 0x1024--0x1027 "BAM_P_PRDCR_SDBND0 (at 0xFC37D024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND0"
        group.long 0x1028--0x102B "BAM_P_CNSMR_SDBND0 (at 0xFC37D028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR0"
        group.long 0x182C--0x182F "BAM_P_EVNT_DEST_ADDR0 (at 0xFC37D82C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG0"
        group.long 0x1818--0x181B "BAM_P_EVNT_REG0 (at 0xFC37D818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS0"
        group.long 0x1800--0x1803 "BAM_P_SW_OFSTS0 (at 0xFC37D800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR0"
        group.long 0x1824--0x1827 "BAM_P_DATA_FIFO_ADDR0 (at 0xFC37D824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR0"
        group.long 0x181C--0x181F "BAM_P_DESC_FIFO_ADDR0 (at 0xFC37D81C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD0"
        group.long 0x1828--0x182B "BAM_P_EVNT_GEN_TRSHLD0 (at 0xFC37D828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES0"
        group.long 0x1820--0x1823 "BAM_P_FIFO_SIZES0 (at 0xFC37D820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_0"
        group.long 0x1834--0x1837 "BAM_P_RETR_CNTXT_0 (at 0xFC37D834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_0"
        group.long 0x1838--0x183B "BAM_P_SI_CNTXT_0 (at 0xFC37D838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_0"
        group.long 0x1830--0x1833 "BAM_P_DF_CNTXT_0 (at 0xFC37D830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_0"
        group.long 0x1804--0x1807 "BAM_P_AU_PSM_CNTXT_1_0 (at 0xFC37D804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_0"
        group.long 0x1808--0x180B "BAM_P_PSM_CNTXT_2_0 (at 0xFC37D808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_0"
        group.long 0x180C--0x180F "BAM_P_PSM_CNTXT_3_0 (at 0xFC37D80C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_0"
        group.long 0x1810--0x1813 "BAM_P_PSM_CNTXT_4_0 (at 0xFC37D810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_0"
        group.long 0x1814--0x1817 "BAM_P_PSM_CNTXT_5_0 (at 0xFC37D814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 0
tree.end
tree "Pipe 1"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL1"
        group.long 0x2000--0x2003 "BAM_P_CTRL1 (at 0xFC37E000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST1"
        group.long 0x2004--0x2007 "BAM_P_RST1 (at 0xFC37E004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT1"
        group.long 0x2008--0x200B "BAM_P_HALT1 (at 0xFC37E008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG1"
        group.long 0x2030--0x2033 "BAM_P_TRUST_REG1 (at 0xFC37E030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS1"
        group.long 0x2010--0x2013 "BAM_P_IRQ_STTS1 (at 0xFC37E010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR1"
        group.long 0x2014--0x2017 "BAM_P_IRQ_CLR1 (at 0xFC37E014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN1"
        group.long 0x2018--0x201B "BAM_P_IRQ_EN1 (at 0xFC37E018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER1"
        group.long 0x201C--0x201F "BAM_P_TIMER1 (at 0xFC37E01C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL1"
        group.long 0x2020--0x2023 "BAM_P_TIMER_CTRL1 (at 0xFC37E020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND1"
        group.long 0x2024--0x2027 "BAM_P_PRDCR_SDBND1 (at 0xFC37E024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND1"
        group.long 0x2028--0x202B "BAM_P_CNSMR_SDBND1 (at 0xFC37E028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR1"
        group.long 0x282C--0x282F "BAM_P_EVNT_DEST_ADDR1 (at 0xFC37E82C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG1"
        group.long 0x2818--0x281B "BAM_P_EVNT_REG1 (at 0xFC37E818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS1"
        group.long 0x2800--0x2803 "BAM_P_SW_OFSTS1 (at 0xFC37E800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR1"
        group.long 0x2824--0x2827 "BAM_P_DATA_FIFO_ADDR1 (at 0xFC37E824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR1"
        group.long 0x281C--0x281F "BAM_P_DESC_FIFO_ADDR1 (at 0xFC37E81C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD1"
        group.long 0x2828--0x282B "BAM_P_EVNT_GEN_TRSHLD1 (at 0xFC37E828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES1"
        group.long 0x2820--0x2823 "BAM_P_FIFO_SIZES1 (at 0xFC37E820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_1"
        group.long 0x2834--0x2837 "BAM_P_RETR_CNTXT_1 (at 0xFC37E834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_1"
        group.long 0x2838--0x283B "BAM_P_SI_CNTXT_1 (at 0xFC37E838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_1"
        group.long 0x2830--0x2833 "BAM_P_DF_CNTXT_1 (at 0xFC37E830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_1"
        group.long 0x2804--0x2807 "BAM_P_AU_PSM_CNTXT_1_1 (at 0xFC37E804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
