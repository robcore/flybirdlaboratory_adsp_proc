        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_3"
        group.long 0x4834--0x4837 "BAM_P_RETR_CNTXT_3 (at 0xF9808834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_3"
        group.long 0x4838--0x483B "BAM_P_SI_CNTXT_3 (at 0xF9808838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_3"
        group.long 0x4830--0x4833 "BAM_P_DF_CNTXT_3 (at 0xF9808830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_3"
        group.long 0x4804--0x4807 "BAM_P_AU_PSM_CNTXT_1_3 (at 0xF9808804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_3"
        group.long 0x4808--0x480B "BAM_P_PSM_CNTXT_2_3 (at 0xF9808808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_3"
        group.long 0x480C--0x480F "BAM_P_PSM_CNTXT_3_3 (at 0xF980880C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_3"
        group.long 0x4810--0x4813 "BAM_P_PSM_CNTXT_4_3 (at 0xF9808810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_3"
        group.long 0x4814--0x4817 "BAM_P_PSM_CNTXT_5_3 (at 0xF9808814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 3
tree.end
tree "Pipe 4"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL4"
        group.long 0x5000--0x5003 "BAM_P_CTRL4 (at 0xF9809000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST4"
        group.long 0x5004--0x5007 "BAM_P_RST4 (at 0xF9809004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT4"
        group.long 0x5008--0x500B "BAM_P_HALT4 (at 0xF9809008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG4"
        group.long 0x5030--0x5033 "BAM_P_TRUST_REG4 (at 0xF9809030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS4"
        group.long 0x5010--0x5013 "BAM_P_IRQ_STTS4 (at 0xF9809010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR4"
        group.long 0x5014--0x5017 "BAM_P_IRQ_CLR4 (at 0xF9809014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN4"
        group.long 0x5018--0x501B "BAM_P_IRQ_EN4 (at 0xF9809018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER4"
        group.long 0x501C--0x501F "BAM_P_TIMER4 (at 0xF980901C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL4"
        group.long 0x5020--0x5023 "BAM_P_TIMER_CTRL4 (at 0xF9809020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND4"
        group.long 0x5024--0x5027 "BAM_P_PRDCR_SDBND4 (at 0xF9809024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND4"
        group.long 0x5028--0x502B "BAM_P_CNSMR_SDBND4 (at 0xF9809028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR4"
        group.long 0x582C--0x582F "BAM_P_EVNT_DEST_ADDR4 (at 0xF980982C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG4"
        group.long 0x5818--0x581B "BAM_P_EVNT_REG4 (at 0xF9809818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS4"
        group.long 0x5800--0x5803 "BAM_P_SW_OFSTS4 (at 0xF9809800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR4"
        group.long 0x5824--0x5827 "BAM_P_DATA_FIFO_ADDR4 (at 0xF9809824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR4"
        group.long 0x581C--0x581F "BAM_P_DESC_FIFO_ADDR4 (at 0xF980981C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD4"
        group.long 0x5828--0x582B "BAM_P_EVNT_GEN_TRSHLD4 (at 0xF9809828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES4"
        group.long 0x5820--0x5823 "BAM_P_FIFO_SIZES4 (at 0xF9809820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_4"
        group.long 0x5834--0x5837 "BAM_P_RETR_CNTXT_4 (at 0xF9809834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_4"
        group.long 0x5838--0x583B "BAM_P_SI_CNTXT_4 (at 0xF9809838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_4"
        group.long 0x5830--0x5833 "BAM_P_DF_CNTXT_4 (at 0xF9809830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_4"
        group.long 0x5804--0x5807 "BAM_P_AU_PSM_CNTXT_1_4 (at 0xF9809804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_4"
        group.long 0x5808--0x580B "BAM_P_PSM_CNTXT_2_4 (at 0xF9809808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_4"
        group.long 0x580C--0x580F "BAM_P_PSM_CNTXT_3_4 (at 0xF980980C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_4"
        group.long 0x5810--0x5813 "BAM_P_PSM_CNTXT_4_4 (at 0xF9809810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_4"
        group.long 0x5814--0x5817 "BAM_P_PSM_CNTXT_5_4 (at 0xF9809814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 4
tree.end
tree "Pipe 5"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL5"
        group.long 0x6000--0x6003 "BAM_P_CTRL5 (at 0xF980A000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST5"
        group.long 0x6004--0x6007 "BAM_P_RST5 (at 0xF980A004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT5"
        group.long 0x6008--0x600B "BAM_P_HALT5 (at 0xF980A008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG5"
        group.long 0x6030--0x6033 "BAM_P_TRUST_REG5 (at 0xF980A030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS5"
        group.long 0x6010--0x6013 "BAM_P_IRQ_STTS5 (at 0xF980A010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR5"
        group.long 0x6014--0x6017 "BAM_P_IRQ_CLR5 (at 0xF980A014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN5"
        group.long 0x6018--0x601B "BAM_P_IRQ_EN5 (at 0xF980A018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER5"
        group.long 0x601C--0x601F "BAM_P_TIMER5 (at 0xF980A01C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL5"
        group.long 0x6020--0x6023 "BAM_P_TIMER_CTRL5 (at 0xF980A020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND5"
        group.long 0x6024--0x6027 "BAM_P_PRDCR_SDBND5 (at 0xF980A024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND5"
        group.long 0x6028--0x602B "BAM_P_CNSMR_SDBND5 (at 0xF980A028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR5"
        group.long 0x682C--0x682F "BAM_P_EVNT_DEST_ADDR5 (at 0xF980A82C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG5"
        group.long 0x6818--0x681B "BAM_P_EVNT_REG5 (at 0xF980A818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS5"
        group.long 0x6800--0x6803 "BAM_P_SW_OFSTS5 (at 0xF980A800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR5"
        group.long 0x6824--0x6827 "BAM_P_DATA_FIFO_ADDR5 (at 0xF980A824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR5"
        group.long 0x681C--0x681F "BAM_P_DESC_FIFO_ADDR5 (at 0xF980A81C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD5"
        group.long 0x6828--0x682B "BAM_P_EVNT_GEN_TRSHLD5 (at 0xF980A828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES5"
        group.long 0x6820--0x6823 "BAM_P_FIFO_SIZES5 (at 0xF980A820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_5"
        group.long 0x6834--0x6837 "BAM_P_RETR_CNTXT_5 (at 0xF980A834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_5"
        group.long 0x6838--0x683B "BAM_P_SI_CNTXT_5 (at 0xF980A838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_5"
        group.long 0x6830--0x6833 "BAM_P_DF_CNTXT_5 (at 0xF980A830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_5"
        group.long 0x6804--0x6807 "BAM_P_AU_PSM_CNTXT_1_5 (at 0xF980A804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_5"
        group.long 0x6808--0x680B "BAM_P_PSM_CNTXT_2_5 (at 0xF980A808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_5"
        group.long 0x680C--0x680F "BAM_P_PSM_CNTXT_3_5 (at 0xF980A80C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_5"
        group.long 0x6810--0x6813 "BAM_P_PSM_CNTXT_4_5 (at 0xF980A810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_5"
        group.long 0x6814--0x6817 "BAM_P_PSM_CNTXT_5_5 (at 0xF980A814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 5
tree.end
tree.end
;Block Per Data Ends

base ad:0xF9844000
tree "SDC2"
tree "BAM Control Registers"
      tree "BAM_CTRL"
        group.long 0x0--0x3 "BAM_CTRL (at 0xF9844000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x13 " [   19]   CACHE_MISS_ERR_RESP_EN                   = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11--0x12 " [18:17]   LOCAL_CLK_GATING                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   IBC_DISABLE                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0xF " [   15]   BAM_CACHED_DESC_STORE                    = "  "0,1"
        textline ""
        bitfld.long 0x0 0xD--0xE " [14:13]   BAM_DESC_CACHE_SEL                       = "  "0,1,2,3"
        textline ""
        hexmask.long.word 0x0 0x5--0xB 1  " [11:05]   BAM_TESTBUS_SEL                          = " 
        textline ""
        bitfld.long 0x0 0x4 " [   04]   BAM_EN_ACCUM                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_EN                                   = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   BAM_SW_RST                               = "  "0,1"
        textline ""
      tree.end
      tree "BAM_REVISION"
        group.long 0x4--0x7 "BAM_REVISION (at 0xF9844004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x18--0x1F 1  " [31:24]   INACTIV_TMR_BASE                         = " 
        textline ""
        bitfld.long 0x0 0x17 " [   23]   CMD_DESC_EN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15--0x16 " [22:21]   DESC_CACHE_DEPTH                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   NUM_INACTIV_TMRS                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x13 " [   19]   INACTIV_TMRS_EXST                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x12 " [   18]   HIGH_FREQUENCY_BAM                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11 " [   17]   BAM_HAS_NO_BYPASS                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   SECURED                                  = "  "0,1"
        textline ""
        bitfld.long 0x0 0xF " [   15]   USE_VMIDMT                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0xE " [   14]   AXI_ACTIVE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0xD " [   13]   CE_BUFFER_SIZE                           = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x8--0xB 1  " [11:08]   NUM_EES                                  = " 
        textline ""
        hexmask.long.word 0x0 0x0--0x7 1  " [07:00]   REVISION                                 = " 
        textline ""
      tree.end
      tree "BAM_SW_VERSION"
        group.long 0x80--0x83 "BAM_SW_VERSION (at 0xF9844080) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x1C--0x1F 1  " [31:28]   MAJOR                                    = " 
        textline ""
        hexmask.long.word 0x0 0x10--0x1B 1  " [27:16]   MINOR                                    = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   STEP                                     = " 
        textline ""
      tree.end
      tree "BAM_NUM_PIPES"
        group.long 0x3C--0x3F "BAM_NUM_PIPES (at 0xF984403C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x18--0x1F 1  " [31:24]   BAM_NON_PIPE_GRP                         = " 
        textline ""
        hexmask.long.word 0x0 0x10--0x17 1  " [23:16]   PERIPH_NON_PIPE_GRP                      = " 
        textline ""
        hexmask.long.word 0x0 0x0--0x7 1  " [07:00]   BAM_NUM_PIPES                            = " 
        textline ""
      tree.end
      tree "BAM_TIMER"
        group.long 0x40--0x43 "BAM_TIMER (at 0xF9844040) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   TIMER                                    = " 
        textline ""
      tree.end
      tree "BAM_TIMER_CTRL"
        group.long 0x44--0x47 "BAM_TIMER_CTRL (at 0xF9844044) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   TIMER_RST                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   TIMER_RUN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   TIMER_MODE                               = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   TIMER_TRSHLD                             = " 
        textline ""
      tree.end
      tree "BAM_DESC_CNT_TRSHLD"
        group.long 0x8--0xB "BAM_DESC_CNT_TRSHLD (at 0xF9844008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   CNT_TRSHLD                               = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS"
        group.long 0xC--0xF "BAM_IRQ_SRCS (at 0xF984400C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK"
        group.long 0x10--0x13 "BAM_IRQ_SRCS_MSK (at 0xF9844010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED"
        group.long 0x30--0x33 "BAM_IRQ_SRCS_UNMASKED (at 0xF9844030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_STTS"
        group.long 0x14--0x17 "BAM_IRQ_STTS (at 0xF9844014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x4 " [   04]   BAM_TIMER_IRQ                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   BAM_EMPTY_IRQ                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_ERROR_IRQ                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_HRESP_ERR_IRQ                        = "  "0,1"
        textline ""
      tree.end
      tree "BAM_IRQ_CLR"
        group.long 0x18--0x1B "BAM_IRQ_CLR (at 0xF9844018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x4 " [   04]   BAM_TIMER_CLR                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   BAM_EMPTY_CLR                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_ERROR_CLR                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_HRESP_ERR_CLR                        = "  "0,1"
        textline ""
      tree.end
      tree "BAM_IRQ_EN"
        group.long 0x1C--0x1F "BAM_IRQ_EN (at 0xF984401C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x4 " [   04]   BAM_TIMER_EN                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   BAM_EMPTY_EN                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_ERROR_EN                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_HRESP_ERR_EN                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_AHB_MASTER_ERR_CTRLS"
        group.long 0x24--0x27 "BAM_AHB_MASTER_ERR_CTRLS (at 0xF9844024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x12--0x16 1  " [22:18]   BAM_ERR_HVMID                            = " 
        textline ""
        bitfld.long 0x0 0x11 " [   17]   BAM_ERR_DIRECT_MODE                      = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0xC--0x10 1  " [16:12]   BAM_ERR_HCID                             = " 
        textline ""
        hexmask.long.word 0x0 0x8--0xB 1  " [11:08]   BAM_ERR_HPROT                            = " 
        textline ""
        bitfld.long 0x0 0x5--0x7 " [07:05]   BAM_ERR_HBURST                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x3--0x4 " [04:03]   BAM_ERR_HSIZE                            = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_ERR_HWRITE                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0--0x1 " [01:00]   BAM_ERR_HTRANS                           = "  "0,1,2,3"
        textline ""
      tree.end
      tree "BAM_AHB_MASTER_ERR_ADDR"
        group.long 0x28--0x2B "BAM_AHB_MASTER_ERR_ADDR (at 0xF9844028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   BAM_ERR_ADDR                             = " 
        textline ""
      tree.end
      tree "BAM_AHB_MASTER_ERR_DATA"
        group.long 0x2C--0x2F "BAM_AHB_MASTER_ERR_DATA (at 0xF984402C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   BAM_ERR_DATA                             = " 
        textline ""
      tree.end
      tree "BAM_TRUST_REG"
        group.long 0x70--0x73 "BAM_TRUST_REG (at 0xF9844070) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0xD " [   13]   LOCK_EE_CTRL                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_VMID                                 = " 
        textline ""
        bitfld.long 0x0 0x7 " [   07]   BAM_RST_BLOCK                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_EE                                   = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_TEST_BUS_SEL"
        group.long 0x74--0x77 "BAM_TEST_BUS_SEL (at 0xF9844074) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x15 " [   21]   SW_EVENTS_ZERO                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x13--0x14 " [20:19]   SW_EVENTS_SEL                            = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x12 " [   18]   BAM_DATA_ERASE                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11 " [   17]   BAM_DATA_FLUSH                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   BAM_CLK_ALWAYS_ON                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x0--0x6 1  " [06:00]   BAM_TESTBUS_SEL                          = " 
        textline ""
      tree.end
      tree "BAM_TEST_BUS_REG"
        group.long 0x78--0x7B "BAM_TEST_BUS_REG (at 0xF9844078) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   BAM_TESTBUS_REG                          = " 
        textline ""
      tree.end
      tree "BAM_CNFG_BITS"
        group.long 0x7C--0x7F "BAM_CNFG_BITS (at 0xF984407C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1C " [   28]   BAM_ZLT_W_CD_SUPPORT                     = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1B " [   27]   BAM_CD_ENABLE                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1A " [   26]   BAM_AU_ACCUMED                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x19 " [   25]   BAM_PSM_P_HD_DATA                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_REG_P_EN                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_WB_DSC_AVL_P_RST                     = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_WB_RETR_SVPNT                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_WB_CSW_ACK_IDL                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_WB_BLK_CSW                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x13 " [   19]   BAM_WB_P_RES                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x12 " [   18]   BAM_SI_P_RES                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11 " [   17]   BAM_AU_P_RES                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   BAM_PSM_P_RES                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0xF " [   15]   BAM_PSM_CSW_REQ                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0xE " [   14]   BAM_SB_CLK_REQ                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0xD " [   13]   BAM_IBC_DISABLE                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0xC " [   12]   BAM_NO_EXT_P_RST                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0xB " [   11]   BAM_FULL_PIPE                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   BAM_ADML_SYNC_BRIDGE                     = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_PIPE_CNFG                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_ADML_DEEP_CONS_FIFO                  = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   BAM_ADML_INCR4_EN_N                      = "  "0,1"
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE0"
        group.long 0x800--0x803 "BAM_IRQ_SRCS_EE0 (at 0xF9844800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE1"
        group.long 0x880--0x883 "BAM_IRQ_SRCS_EE1 (at 0xF9844880) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE2"
        group.long 0x900--0x903 "BAM_IRQ_SRCS_EE2 (at 0xF9844900) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE3"
        group.long 0x980--0x983 "BAM_IRQ_SRCS_EE3 (at 0xF9844980) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE4"
        group.long 0xA00--0xA03 "BAM_IRQ_SRCS_EE4 (at 0xF9844A00) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE5"
        group.long 0xA80--0xA83 "BAM_IRQ_SRCS_EE5 (at 0xF9844A80) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE6"
        group.long 0xB00--0xB03 "BAM_IRQ_SRCS_EE6 (at 0xF9844B00) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE7"
        group.long 0xB80--0xB83 "BAM_IRQ_SRCS_EE7 (at 0xF9844B80) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE0"
        group.long 0x804--0x807 "BAM_IRQ_SRCS_MSK_EE0 (at 0xF9844804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE1"
        group.long 0x884--0x887 "BAM_IRQ_SRCS_MSK_EE1 (at 0xF9844884) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE2"
        group.long 0x904--0x907 "BAM_IRQ_SRCS_MSK_EE2 (at 0xF9844904) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE3"
        group.long 0x984--0x987 "BAM_IRQ_SRCS_MSK_EE3 (at 0xF9844984) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE4"
        group.long 0xA04--0xA07 "BAM_IRQ_SRCS_MSK_EE4 (at 0xF9844A04) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE5"
        group.long 0xA84--0xA87 "BAM_IRQ_SRCS_MSK_EE5 (at 0xF9844A84) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE6"
        group.long 0xB04--0xB07 "BAM_IRQ_SRCS_MSK_EE6 (at 0xF9844B04) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE7"
        group.long 0xB84--0xB87 "BAM_IRQ_SRCS_MSK_EE7 (at 0xF9844B84) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE0"
        group.long 0x808--0x80B "BAM_IRQ_SRCS_UNMASKED_EE0 (at 0xF9844808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE1"
        group.long 0x888--0x88B "BAM_IRQ_SRCS_UNMASKED_EE1 (at 0xF9844888) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE2"
        group.long 0x908--0x90B "BAM_IRQ_SRCS_UNMASKED_EE2 (at 0xF9844908) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE3"
        group.long 0x988--0x98B "BAM_IRQ_SRCS_UNMASKED_EE3 (at 0xF9844988) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE4"
        group.long 0xA08--0xA0B "BAM_IRQ_SRCS_UNMASKED_EE4 (at 0xF9844A08) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE5"
        group.long 0xA88--0xA8B "BAM_IRQ_SRCS_UNMASKED_EE5 (at 0xF9844A88) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE6"
        group.long 0xB08--0xB0B "BAM_IRQ_SRCS_UNMASKED_EE6 (at 0xF9844B08) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE7"
        group.long 0xB88--0xB8B "BAM_IRQ_SRCS_UNMASKED_EE7 (at 0xF9844B88) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
;End of BAM Control Registers
tree.end
tree "Pipe 0"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL0"
        group.long 0x1000--0x1003 "BAM_P_CTRL0 (at 0xF9845000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST0"
        group.long 0x1004--0x1007 "BAM_P_RST0 (at 0xF9845004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT0"
        group.long 0x1008--0x100B "BAM_P_HALT0 (at 0xF9845008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG0"
        group.long 0x1030--0x1033 "BAM_P_TRUST_REG0 (at 0xF9845030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS0"
        group.long 0x1010--0x1013 "BAM_P_IRQ_STTS0 (at 0xF9845010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR0"
        group.long 0x1014--0x1017 "BAM_P_IRQ_CLR0 (at 0xF9845014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN0"
        group.long 0x1018--0x101B "BAM_P_IRQ_EN0 (at 0xF9845018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER0"
        group.long 0x101C--0x101F "BAM_P_TIMER0 (at 0xF984501C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL0"
        group.long 0x1020--0x1023 "BAM_P_TIMER_CTRL0 (at 0xF9845020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND0"
        group.long 0x1024--0x1027 "BAM_P_PRDCR_SDBND0 (at 0xF9845024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND0"
        group.long 0x1028--0x102B "BAM_P_CNSMR_SDBND0 (at 0xF9845028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR0"
        group.long 0x182C--0x182F "BAM_P_EVNT_DEST_ADDR0 (at 0xF984582C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG0"
        group.long 0x1818--0x181B "BAM_P_EVNT_REG0 (at 0xF9845818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS0"
        group.long 0x1800--0x1803 "BAM_P_SW_OFSTS0 (at 0xF9845800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR0"
        group.long 0x1824--0x1827 "BAM_P_DATA_FIFO_ADDR0 (at 0xF9845824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR0"
        group.long 0x181C--0x181F "BAM_P_DESC_FIFO_ADDR0 (at 0xF984581C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD0"
        group.long 0x1828--0x182B "BAM_P_EVNT_GEN_TRSHLD0 (at 0xF9845828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES0"
        group.long 0x1820--0x1823 "BAM_P_FIFO_SIZES0 (at 0xF9845820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_0"
        group.long 0x1834--0x1837 "BAM_P_RETR_CNTXT_0 (at 0xF9845834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_0"
        group.long 0x1838--0x183B "BAM_P_SI_CNTXT_0 (at 0xF9845838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_0"
        group.long 0x1830--0x1833 "BAM_P_DF_CNTXT_0 (at 0xF9845830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_0"
        group.long 0x1804--0x1807 "BAM_P_AU_PSM_CNTXT_1_0 (at 0xF9845804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_0"
        group.long 0x1808--0x180B "BAM_P_PSM_CNTXT_2_0 (at 0xF9845808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_0"
        group.long 0x180C--0x180F "BAM_P_PSM_CNTXT_3_0 (at 0xF984580C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_0"
        group.long 0x1810--0x1813 "BAM_P_PSM_CNTXT_4_0 (at 0xF9845810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_0"
        group.long 0x1814--0x1817 "BAM_P_PSM_CNTXT_5_0 (at 0xF9845814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 0
tree.end
tree "Pipe 1"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL1"
        group.long 0x2000--0x2003 "BAM_P_CTRL1 (at 0xF9846000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST1"
        group.long 0x2004--0x2007 "BAM_P_RST1 (at 0xF9846004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT1"
        group.long 0x2008--0x200B "BAM_P_HALT1 (at 0xF9846008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG1"
        group.long 0x2030--0x2033 "BAM_P_TRUST_REG1 (at 0xF9846030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS1"
        group.long 0x2010--0x2013 "BAM_P_IRQ_STTS1 (at 0xF9846010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR1"
        group.long 0x2014--0x2017 "BAM_P_IRQ_CLR1 (at 0xF9846014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN1"
        group.long 0x2018--0x201B "BAM_P_IRQ_EN1 (at 0xF9846018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER1"
        group.long 0x201C--0x201F "BAM_P_TIMER1 (at 0xF984601C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL1"
        group.long 0x2020--0x2023 "BAM_P_TIMER_CTRL1 (at 0xF9846020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND1"
        group.long 0x2024--0x2027 "BAM_P_PRDCR_SDBND1 (at 0xF9846024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND1"
        group.long 0x2028--0x202B "BAM_P_CNSMR_SDBND1 (at 0xF9846028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR1"
        group.long 0x282C--0x282F "BAM_P_EVNT_DEST_ADDR1 (at 0xF984682C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG1"
        group.long 0x2818--0x281B "BAM_P_EVNT_REG1 (at 0xF9846818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS1"
        group.long 0x2800--0x2803 "BAM_P_SW_OFSTS1 (at 0xF9846800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR1"
        group.long 0x2824--0x2827 "BAM_P_DATA_FIFO_ADDR1 (at 0xF9846824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR1"
        group.long 0x281C--0x281F "BAM_P_DESC_FIFO_ADDR1 (at 0xF984681C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD1"
        group.long 0x2828--0x282B "BAM_P_EVNT_GEN_TRSHLD1 (at 0xF9846828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES1"
        group.long 0x2820--0x2823 "BAM_P_FIFO_SIZES1 (at 0xF9846820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_1"
        group.long 0x2834--0x2837 "BAM_P_RETR_CNTXT_1 (at 0xF9846834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_1"
        group.long 0x2838--0x283B "BAM_P_SI_CNTXT_1 (at 0xF9846838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_1"
        group.long 0x2830--0x2833 "BAM_P_DF_CNTXT_1 (at 0xF9846830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_1"
        group.long 0x2804--0x2807 "BAM_P_AU_PSM_CNTXT_1_1 (at 0xF9846804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_1"
        group.long 0x2808--0x280B "BAM_P_PSM_CNTXT_2_1 (at 0xF9846808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_1"
        group.long 0x280C--0x280F "BAM_P_PSM_CNTXT_3_1 (at 0xF984680C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_1"
        group.long 0x2810--0x2813 "BAM_P_PSM_CNTXT_4_1 (at 0xF9846810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_1"
        group.long 0x2814--0x2817 "BAM_P_PSM_CNTXT_5_1 (at 0xF9846814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 1
tree.end
tree "Pipe 2"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL2"
        group.long 0x3000--0x3003 "BAM_P_CTRL2 (at 0xF9847000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST2"
        group.long 0x3004--0x3007 "BAM_P_RST2 (at 0xF9847004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT2"
        group.long 0x3008--0x300B "BAM_P_HALT2 (at 0xF9847008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG2"
        group.long 0x3030--0x3033 "BAM_P_TRUST_REG2 (at 0xF9847030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS2"
        group.long 0x3010--0x3013 "BAM_P_IRQ_STTS2 (at 0xF9847010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR2"
        group.long 0x3014--0x3017 "BAM_P_IRQ_CLR2 (at 0xF9847014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN2"
        group.long 0x3018--0x301B "BAM_P_IRQ_EN2 (at 0xF9847018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER2"
        group.long 0x301C--0x301F "BAM_P_TIMER2 (at 0xF984701C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL2"
        group.long 0x3020--0x3023 "BAM_P_TIMER_CTRL2 (at 0xF9847020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND2"
        group.long 0x3024--0x3027 "BAM_P_PRDCR_SDBND2 (at 0xF9847024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND2"
        group.long 0x3028--0x302B "BAM_P_CNSMR_SDBND2 (at 0xF9847028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR2"
        group.long 0x382C--0x382F "BAM_P_EVNT_DEST_ADDR2 (at 0xF984782C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG2"
        group.long 0x3818--0x381B "BAM_P_EVNT_REG2 (at 0xF9847818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS2"
        group.long 0x3800--0x3803 "BAM_P_SW_OFSTS2 (at 0xF9847800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR2"
        group.long 0x3824--0x3827 "BAM_P_DATA_FIFO_ADDR2 (at 0xF9847824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR2"
        group.long 0x381C--0x381F "BAM_P_DESC_FIFO_ADDR2 (at 0xF984781C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD2"
        group.long 0x3828--0x382B "BAM_P_EVNT_GEN_TRSHLD2 (at 0xF9847828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES2"
        group.long 0x3820--0x3823 "BAM_P_FIFO_SIZES2 (at 0xF9847820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_2"
        group.long 0x3834--0x3837 "BAM_P_RETR_CNTXT_2 (at 0xF9847834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_2"
        group.long 0x3838--0x383B "BAM_P_SI_CNTXT_2 (at 0xF9847838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_2"
        group.long 0x3830--0x3833 "BAM_P_DF_CNTXT_2 (at 0xF9847830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_2"
        group.long 0x3804--0x3807 "BAM_P_AU_PSM_CNTXT_1_2 (at 0xF9847804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_2"
        group.long 0x3808--0x380B "BAM_P_PSM_CNTXT_2_2 (at 0xF9847808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_2"
        group.long 0x380C--0x380F "BAM_P_PSM_CNTXT_3_2 (at 0xF984780C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_2"
        group.long 0x3810--0x3813 "BAM_P_PSM_CNTXT_4_2 (at 0xF9847810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_2"
        group.long 0x3814--0x3817 "BAM_P_PSM_CNTXT_5_2 (at 0xF9847814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 2
tree.end
tree "Pipe 3"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL3"
        group.long 0x4000--0x4003 "BAM_P_CTRL3 (at 0xF9848000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST3"
        group.long 0x4004--0x4007 "BAM_P_RST3 (at 0xF9848004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT3"
        group.long 0x4008--0x400B "BAM_P_HALT3 (at 0xF9848008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG3"
        group.long 0x4030--0x4033 "BAM_P_TRUST_REG3 (at 0xF9848030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS3"
        group.long 0x4010--0x4013 "BAM_P_IRQ_STTS3 (at 0xF9848010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR3"
        group.long 0x4014--0x4017 "BAM_P_IRQ_CLR3 (at 0xF9848014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN3"
        group.long 0x4018--0x401B "BAM_P_IRQ_EN3 (at 0xF9848018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER3"
        group.long 0x401C--0x401F "BAM_P_TIMER3 (at 0xF984801C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL3"
        group.long 0x4020--0x4023 "BAM_P_TIMER_CTRL3 (at 0xF9848020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND3"
        group.long 0x4024--0x4027 "BAM_P_PRDCR_SDBND3 (at 0xF9848024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND3"
        group.long 0x4028--0x402B "BAM_P_CNSMR_SDBND3 (at 0xF9848028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR3"
        group.long 0x482C--0x482F "BAM_P_EVNT_DEST_ADDR3 (at 0xF984882C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG3"
        group.long 0x4818--0x481B "BAM_P_EVNT_REG3 (at 0xF9848818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS3"
        group.long 0x4800--0x4803 "BAM_P_SW_OFSTS3 (at 0xF9848800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR3"
        group.long 0x4824--0x4827 "BAM_P_DATA_FIFO_ADDR3 (at 0xF9848824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR3"
        group.long 0x481C--0x481F "BAM_P_DESC_FIFO_ADDR3 (at 0xF984881C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD3"
        group.long 0x4828--0x482B "BAM_P_EVNT_GEN_TRSHLD3 (at 0xF9848828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES3"
        group.long 0x4820--0x4823 "BAM_P_FIFO_SIZES3 (at 0xF9848820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_3"
        group.long 0x4834--0x4837 "BAM_P_RETR_CNTXT_3 (at 0xF9848834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_3"
        group.long 0x4838--0x483B "BAM_P_SI_CNTXT_3 (at 0xF9848838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_3"
        group.long 0x4830--0x4833 "BAM_P_DF_CNTXT_3 (at 0xF9848830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_3"
        group.long 0x4804--0x4807 "BAM_P_AU_PSM_CNTXT_1_3 (at 0xF9848804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_3"
        group.long 0x4808--0x480B "BAM_P_PSM_CNTXT_2_3 (at 0xF9848808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_3"
        group.long 0x480C--0x480F "BAM_P_PSM_CNTXT_3_3 (at 0xF984880C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_3"
        group.long 0x4810--0x4813 "BAM_P_PSM_CNTXT_4_3 (at 0xF9848810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_3"
        group.long 0x4814--0x4817 "BAM_P_PSM_CNTXT_5_3 (at 0xF9848814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 3
tree.end
tree "Pipe 4"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL4"
        group.long 0x5000--0x5003 "BAM_P_CTRL4 (at 0xF9849000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST4"
        group.long 0x5004--0x5007 "BAM_P_RST4 (at 0xF9849004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT4"
        group.long 0x5008--0x500B "BAM_P_HALT4 (at 0xF9849008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG4"
        group.long 0x5030--0x5033 "BAM_P_TRUST_REG4 (at 0xF9849030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS4"
        group.long 0x5010--0x5013 "BAM_P_IRQ_STTS4 (at 0xF9849010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR4"
        group.long 0x5014--0x5017 "BAM_P_IRQ_CLR4 (at 0xF9849014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN4"
        group.long 0x5018--0x501B "BAM_P_IRQ_EN4 (at 0xF9849018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER4"
        group.long 0x501C--0x501F "BAM_P_TIMER4 (at 0xF984901C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL4"
        group.long 0x5020--0x5023 "BAM_P_TIMER_CTRL4 (at 0xF9849020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND4"
        group.long 0x5024--0x5027 "BAM_P_PRDCR_SDBND4 (at 0xF9849024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND4"
        group.long 0x5028--0x502B "BAM_P_CNSMR_SDBND4 (at 0xF9849028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR4"
        group.long 0x582C--0x582F "BAM_P_EVNT_DEST_ADDR4 (at 0xF984982C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG4"
        group.long 0x5818--0x581B "BAM_P_EVNT_REG4 (at 0xF9849818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS4"
        group.long 0x5800--0x5803 "BAM_P_SW_OFSTS4 (at 0xF9849800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR4"
        group.long 0x5824--0x5827 "BAM_P_DATA_FIFO_ADDR4 (at 0xF9849824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR4"
        group.long 0x581C--0x581F "BAM_P_DESC_FIFO_ADDR4 (at 0xF984981C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD4"
        group.long 0x5828--0x582B "BAM_P_EVNT_GEN_TRSHLD4 (at 0xF9849828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES4"
        group.long 0x5820--0x5823 "BAM_P_FIFO_SIZES4 (at 0xF9849820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_4"
        group.long 0x5834--0x5837 "BAM_P_RETR_CNTXT_4 (at 0xF9849834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_4"
        group.long 0x5838--0x583B "BAM_P_SI_CNTXT_4 (at 0xF9849838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_4"
        group.long 0x5830--0x5833 "BAM_P_DF_CNTXT_4 (at 0xF9849830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_4"
        group.long 0x5804--0x5807 "BAM_P_AU_PSM_CNTXT_1_4 (at 0xF9849804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_4"
        group.long 0x5808--0x580B "BAM_P_PSM_CNTXT_2_4 (at 0xF9849808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_4"
        group.long 0x580C--0x580F "BAM_P_PSM_CNTXT_3_4 (at 0xF984980C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_4"
        group.long 0x5810--0x5813 "BAM_P_PSM_CNTXT_4_4 (at 0xF9849810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_4"
        group.long 0x5814--0x5817 "BAM_P_PSM_CNTXT_5_4 (at 0xF9849814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 4
tree.end
tree "Pipe 5"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL5"
        group.long 0x6000--0x6003 "BAM_P_CTRL5 (at 0xF984A000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST5"
        group.long 0x6004--0x6007 "BAM_P_RST5 (at 0xF984A004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT5"
        group.long 0x6008--0x600B "BAM_P_HALT5 (at 0xF984A008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG5"
        group.long 0x6030--0x6033 "BAM_P_TRUST_REG5 (at 0xF984A030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS5"
        group.long 0x6010--0x6013 "BAM_P_IRQ_STTS5 (at 0xF984A010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR5"
        group.long 0x6014--0x6017 "BAM_P_IRQ_CLR5 (at 0xF984A014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN5"
        group.long 0x6018--0x601B "BAM_P_IRQ_EN5 (at 0xF984A018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER5"
        group.long 0x601C--0x601F "BAM_P_TIMER5 (at 0xF984A01C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL5"
        group.long 0x6020--0x6023 "BAM_P_TIMER_CTRL5 (at 0xF984A020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND5"
        group.long 0x6024--0x6027 "BAM_P_PRDCR_SDBND5 (at 0xF984A024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND5"
        group.long 0x6028--0x602B "BAM_P_CNSMR_SDBND5 (at 0xF984A028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR5"
        group.long 0x682C--0x682F "BAM_P_EVNT_DEST_ADDR5 (at 0xF984A82C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG5"
        group.long 0x6818--0x681B "BAM_P_EVNT_REG5 (at 0xF984A818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS5"
        group.long 0x6800--0x6803 "BAM_P_SW_OFSTS5 (at 0xF984A800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR5"
        group.long 0x6824--0x6827 "BAM_P_DATA_FIFO_ADDR5 (at 0xF984A824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR5"
        group.long 0x681C--0x681F "BAM_P_DESC_FIFO_ADDR5 (at 0xF984A81C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD5"
        group.long 0x6828--0x682B "BAM_P_EVNT_GEN_TRSHLD5 (at 0xF984A828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES5"
        group.long 0x6820--0x6823 "BAM_P_FIFO_SIZES5 (at 0xF984A820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_5"
        group.long 0x6834--0x6837 "BAM_P_RETR_CNTXT_5 (at 0xF984A834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_5"
        group.long 0x6838--0x683B "BAM_P_SI_CNTXT_5 (at 0xF984A838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_5"
        group.long 0x6830--0x6833 "BAM_P_DF_CNTXT_5 (at 0xF984A830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_5"
        group.long 0x6804--0x6807 "BAM_P_AU_PSM_CNTXT_1_5 (at 0xF984A804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_5"
        group.long 0x6808--0x680B "BAM_P_PSM_CNTXT_2_5 (at 0xF984A808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_5"
        group.long 0x680C--0x680F "BAM_P_PSM_CNTXT_3_5 (at 0xF984A80C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_5"
        group.long 0x6810--0x6813 "BAM_P_PSM_CNTXT_4_5 (at 0xF984A810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_5"
        group.long 0x6814--0x6817 "BAM_P_PSM_CNTXT_5_5 (at 0xF984A814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 5
tree.end
tree.end
;Block Per Data Ends

base ad:0xF9884000
tree "SDC3"
tree "BAM Control Registers"
      tree "BAM_CTRL"
        group.long 0x0--0x3 "BAM_CTRL (at 0xF9884000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x13 " [   19]   CACHE_MISS_ERR_RESP_EN                   = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11--0x12 " [18:17]   LOCAL_CLK_GATING                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   IBC_DISABLE                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0xF " [   15]   BAM_CACHED_DESC_STORE                    = "  "0,1"
        textline ""
        bitfld.long 0x0 0xD--0xE " [14:13]   BAM_DESC_CACHE_SEL                       = "  "0,1,2,3"
        textline ""
        hexmask.long.word 0x0 0x5--0xB 1  " [11:05]   BAM_TESTBUS_SEL                          = " 
        textline ""
        bitfld.long 0x0 0x4 " [   04]   BAM_EN_ACCUM                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_EN                                   = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   BAM_SW_RST                               = "  "0,1"
        textline ""
      tree.end
      tree "BAM_REVISION"
        group.long 0x4--0x7 "BAM_REVISION (at 0xF9884004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x18--0x1F 1  " [31:24]   INACTIV_TMR_BASE                         = " 
        textline ""
        bitfld.long 0x0 0x17 " [   23]   CMD_DESC_EN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15--0x16 " [22:21]   DESC_CACHE_DEPTH                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   NUM_INACTIV_TMRS                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x13 " [   19]   INACTIV_TMRS_EXST                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x12 " [   18]   HIGH_FREQUENCY_BAM                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11 " [   17]   BAM_HAS_NO_BYPASS                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   SECURED                                  = "  "0,1"
        textline ""
        bitfld.long 0x0 0xF " [   15]   USE_VMIDMT                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0xE " [   14]   AXI_ACTIVE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0xD " [   13]   CE_BUFFER_SIZE                           = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x8--0xB 1  " [11:08]   NUM_EES                                  = " 
        textline ""
        hexmask.long.word 0x0 0x0--0x7 1  " [07:00]   REVISION                                 = " 
        textline ""
      tree.end
      tree "BAM_SW_VERSION"
        group.long 0x80--0x83 "BAM_SW_VERSION (at 0xF9884080) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x1C--0x1F 1  " [31:28]   MAJOR                                    = " 
        textline ""
        hexmask.long.word 0x0 0x10--0x1B 1  " [27:16]   MINOR                                    = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   STEP                                     = " 
        textline ""
      tree.end
      tree "BAM_NUM_PIPES"
        group.long 0x3C--0x3F "BAM_NUM_PIPES (at 0xF988403C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x18--0x1F 1  " [31:24]   BAM_NON_PIPE_GRP                         = " 
        textline ""
        hexmask.long.word 0x0 0x10--0x17 1  " [23:16]   PERIPH_NON_PIPE_GRP                      = " 
        textline ""
        hexmask.long.word 0x0 0x0--0x7 1  " [07:00]   BAM_NUM_PIPES                            = " 
        textline ""
      tree.end
      tree "BAM_TIMER"
        group.long 0x40--0x43 "BAM_TIMER (at 0xF9884040) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   TIMER                                    = " 
        textline ""
      tree.end
      tree "BAM_TIMER_CTRL"
        group.long 0x44--0x47 "BAM_TIMER_CTRL (at 0xF9884044) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   TIMER_RST                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   TIMER_RUN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   TIMER_MODE                               = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   TIMER_TRSHLD                             = " 
        textline ""
      tree.end
      tree "BAM_DESC_CNT_TRSHLD"
        group.long 0x8--0xB "BAM_DESC_CNT_TRSHLD (at 0xF9884008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   CNT_TRSHLD                               = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS"
        group.long 0xC--0xF "BAM_IRQ_SRCS (at 0xF988400C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK"
        group.long 0x10--0x13 "BAM_IRQ_SRCS_MSK (at 0xF9884010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED"
        group.long 0x30--0x33 "BAM_IRQ_SRCS_UNMASKED (at 0xF9884030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_STTS"
        group.long 0x14--0x17 "BAM_IRQ_STTS (at 0xF9884014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x4 " [   04]   BAM_TIMER_IRQ                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   BAM_EMPTY_IRQ                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_ERROR_IRQ                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_HRESP_ERR_IRQ                        = "  "0,1"
        textline ""
      tree.end
      tree "BAM_IRQ_CLR"
        group.long 0x18--0x1B "BAM_IRQ_CLR (at 0xF9884018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x4 " [   04]   BAM_TIMER_CLR                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   BAM_EMPTY_CLR                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_ERROR_CLR                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_HRESP_ERR_CLR                        = "  "0,1"
        textline ""
      tree.end
      tree "BAM_IRQ_EN"
        group.long 0x1C--0x1F "BAM_IRQ_EN (at 0xF988401C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x4 " [   04]   BAM_TIMER_EN                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   BAM_EMPTY_EN                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_ERROR_EN                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_HRESP_ERR_EN                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_AHB_MASTER_ERR_CTRLS"
        group.long 0x24--0x27 "BAM_AHB_MASTER_ERR_CTRLS (at 0xF9884024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x12--0x16 1  " [22:18]   BAM_ERR_HVMID                            = " 
        textline ""
        bitfld.long 0x0 0x11 " [   17]   BAM_ERR_DIRECT_MODE                      = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0xC--0x10 1  " [16:12]   BAM_ERR_HCID                             = " 
        textline ""
        hexmask.long.word 0x0 0x8--0xB 1  " [11:08]   BAM_ERR_HPROT                            = " 
        textline ""
        bitfld.long 0x0 0x5--0x7 " [07:05]   BAM_ERR_HBURST                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x3--0x4 " [04:03]   BAM_ERR_HSIZE                            = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_ERR_HWRITE                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0--0x1 " [01:00]   BAM_ERR_HTRANS                           = "  "0,1,2,3"
        textline ""
      tree.end
      tree "BAM_AHB_MASTER_ERR_ADDR"
        group.long 0x28--0x2B "BAM_AHB_MASTER_ERR_ADDR (at 0xF9884028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   BAM_ERR_ADDR                             = " 
        textline ""
      tree.end
      tree "BAM_AHB_MASTER_ERR_DATA"
        group.long 0x2C--0x2F "BAM_AHB_MASTER_ERR_DATA (at 0xF988402C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   BAM_ERR_DATA                             = " 
        textline ""
      tree.end
      tree "BAM_TRUST_REG"
        group.long 0x70--0x73 "BAM_TRUST_REG (at 0xF9884070) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0xD " [   13]   LOCK_EE_CTRL                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_VMID                                 = " 
        textline ""
        bitfld.long 0x0 0x7 " [   07]   BAM_RST_BLOCK                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_EE                                   = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_TEST_BUS_SEL"
        group.long 0x74--0x77 "BAM_TEST_BUS_SEL (at 0xF9884074) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x15 " [   21]   SW_EVENTS_ZERO                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x13--0x14 " [20:19]   SW_EVENTS_SEL                            = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x12 " [   18]   BAM_DATA_ERASE                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11 " [   17]   BAM_DATA_FLUSH                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   BAM_CLK_ALWAYS_ON                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x0--0x6 1  " [06:00]   BAM_TESTBUS_SEL                          = " 
        textline ""
      tree.end
      tree "BAM_TEST_BUS_REG"
        group.long 0x78--0x7B "BAM_TEST_BUS_REG (at 0xF9884078) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   BAM_TESTBUS_REG                          = " 
        textline ""
      tree.end
      tree "BAM_CNFG_BITS"
        group.long 0x7C--0x7F "BAM_CNFG_BITS (at 0xF988407C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1C " [   28]   BAM_ZLT_W_CD_SUPPORT                     = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1B " [   27]   BAM_CD_ENABLE                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1A " [   26]   BAM_AU_ACCUMED                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x19 " [   25]   BAM_PSM_P_HD_DATA                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_REG_P_EN                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_WB_DSC_AVL_P_RST                     = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_WB_RETR_SVPNT                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_WB_CSW_ACK_IDL                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_WB_BLK_CSW                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x13 " [   19]   BAM_WB_P_RES                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x12 " [   18]   BAM_SI_P_RES                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11 " [   17]   BAM_AU_P_RES                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   BAM_PSM_P_RES                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0xF " [   15]   BAM_PSM_CSW_REQ                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0xE " [   14]   BAM_SB_CLK_REQ                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0xD " [   13]   BAM_IBC_DISABLE                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0xC " [   12]   BAM_NO_EXT_P_RST                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0xB " [   11]   BAM_FULL_PIPE                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   BAM_ADML_SYNC_BRIDGE                     = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_PIPE_CNFG                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_ADML_DEEP_CONS_FIFO                  = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   BAM_ADML_INCR4_EN_N                      = "  "0,1"
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE0"
        group.long 0x800--0x803 "BAM_IRQ_SRCS_EE0 (at 0xF9884800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE1"
        group.long 0x880--0x883 "BAM_IRQ_SRCS_EE1 (at 0xF9884880) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE2"
        group.long 0x900--0x903 "BAM_IRQ_SRCS_EE2 (at 0xF9884900) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE3"
        group.long 0x980--0x983 "BAM_IRQ_SRCS_EE3 (at 0xF9884980) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE4"
        group.long 0xA00--0xA03 "BAM_IRQ_SRCS_EE4 (at 0xF9884A00) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE5"
        group.long 0xA80--0xA83 "BAM_IRQ_SRCS_EE5 (at 0xF9884A80) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE6"
        group.long 0xB00--0xB03 "BAM_IRQ_SRCS_EE6 (at 0xF9884B00) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE7"
        group.long 0xB80--0xB83 "BAM_IRQ_SRCS_EE7 (at 0xF9884B80) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE0"
        group.long 0x804--0x807 "BAM_IRQ_SRCS_MSK_EE0 (at 0xF9884804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE1"
        group.long 0x884--0x887 "BAM_IRQ_SRCS_MSK_EE1 (at 0xF9884884) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE2"
        group.long 0x904--0x907 "BAM_IRQ_SRCS_MSK_EE2 (at 0xF9884904) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE3"
        group.long 0x984--0x987 "BAM_IRQ_SRCS_MSK_EE3 (at 0xF9884984) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE4"
        group.long 0xA04--0xA07 "BAM_IRQ_SRCS_MSK_EE4 (at 0xF9884A04) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE5"
        group.long 0xA84--0xA87 "BAM_IRQ_SRCS_MSK_EE5 (at 0xF9884A84) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE6"
        group.long 0xB04--0xB07 "BAM_IRQ_SRCS_MSK_EE6 (at 0xF9884B04) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE7"
        group.long 0xB84--0xB87 "BAM_IRQ_SRCS_MSK_EE7 (at 0xF9884B84) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE0"
        group.long 0x808--0x80B "BAM_IRQ_SRCS_UNMASKED_EE0 (at 0xF9884808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE1"
        group.long 0x888--0x88B "BAM_IRQ_SRCS_UNMASKED_EE1 (at 0xF9884888) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE2"
        group.long 0x908--0x90B "BAM_IRQ_SRCS_UNMASKED_EE2 (at 0xF9884908) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE3"
        group.long 0x988--0x98B "BAM_IRQ_SRCS_UNMASKED_EE3 (at 0xF9884988) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE4"
        group.long 0xA08--0xA0B "BAM_IRQ_SRCS_UNMASKED_EE4 (at 0xF9884A08) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE5"
        group.long 0xA88--0xA8B "BAM_IRQ_SRCS_UNMASKED_EE5 (at 0xF9884A88) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE6"
        group.long 0xB08--0xB0B "BAM_IRQ_SRCS_UNMASKED_EE6 (at 0xF9884B08) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE7"
        group.long 0xB88--0xB8B "BAM_IRQ_SRCS_UNMASKED_EE7 (at 0xF9884B88) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
;End of BAM Control Registers
tree.end
tree "Pipe 0"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL0"
        group.long 0x1000--0x1003 "BAM_P_CTRL0 (at 0xF9885000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST0"
        group.long 0x1004--0x1007 "BAM_P_RST0 (at 0xF9885004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT0"
        group.long 0x1008--0x100B "BAM_P_HALT0 (at 0xF9885008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG0"
        group.long 0x1030--0x1033 "BAM_P_TRUST_REG0 (at 0xF9885030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS0"
        group.long 0x1010--0x1013 "BAM_P_IRQ_STTS0 (at 0xF9885010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR0"
        group.long 0x1014--0x1017 "BAM_P_IRQ_CLR0 (at 0xF9885014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN0"
        group.long 0x1018--0x101B "BAM_P_IRQ_EN0 (at 0xF9885018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER0"
        group.long 0x101C--0x101F "BAM_P_TIMER0 (at 0xF988501C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL0"
        group.long 0x1020--0x1023 "BAM_P_TIMER_CTRL0 (at 0xF9885020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND0"
        group.long 0x1024--0x1027 "BAM_P_PRDCR_SDBND0 (at 0xF9885024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND0"
        group.long 0x1028--0x102B "BAM_P_CNSMR_SDBND0 (at 0xF9885028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR0"
        group.long 0x182C--0x182F "BAM_P_EVNT_DEST_ADDR0 (at 0xF988582C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG0"
        group.long 0x1818--0x181B "BAM_P_EVNT_REG0 (at 0xF9885818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS0"
        group.long 0x1800--0x1803 "BAM_P_SW_OFSTS0 (at 0xF9885800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR0"
        group.long 0x1824--0x1827 "BAM_P_DATA_FIFO_ADDR0 (at 0xF9885824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR0"
        group.long 0x181C--0x181F "BAM_P_DESC_FIFO_ADDR0 (at 0xF988581C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD0"
        group.long 0x1828--0x182B "BAM_P_EVNT_GEN_TRSHLD0 (at 0xF9885828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES0"
        group.long 0x1820--0x1823 "BAM_P_FIFO_SIZES0 (at 0xF9885820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_0"
        group.long 0x1834--0x1837 "BAM_P_RETR_CNTXT_0 (at 0xF9885834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_0"
        group.long 0x1838--0x183B "BAM_P_SI_CNTXT_0 (at 0xF9885838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_0"
        group.long 0x1830--0x1833 "BAM_P_DF_CNTXT_0 (at 0xF9885830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_0"
        group.long 0x1804--0x1807 "BAM_P_AU_PSM_CNTXT_1_0 (at 0xF9885804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_0"
        group.long 0x1808--0x180B "BAM_P_PSM_CNTXT_2_0 (at 0xF9885808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_0"
        group.long 0x180C--0x180F "BAM_P_PSM_CNTXT_3_0 (at 0xF988580C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_0"
        group.long 0x1810--0x1813 "BAM_P_PSM_CNTXT_4_0 (at 0xF9885810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_0"
        group.long 0x1814--0x1817 "BAM_P_PSM_CNTXT_5_0 (at 0xF9885814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 0
tree.end
tree "Pipe 1"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL1"
        group.long 0x2000--0x2003 "BAM_P_CTRL1 (at 0xF9886000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST1"
        group.long 0x2004--0x2007 "BAM_P_RST1 (at 0xF9886004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT1"
        group.long 0x2008--0x200B "BAM_P_HALT1 (at 0xF9886008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG1"
        group.long 0x2030--0x2033 "BAM_P_TRUST_REG1 (at 0xF9886030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS1"
        group.long 0x2010--0x2013 "BAM_P_IRQ_STTS1 (at 0xF9886010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR1"
        group.long 0x2014--0x2017 "BAM_P_IRQ_CLR1 (at 0xF9886014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN1"
        group.long 0x2018--0x201B "BAM_P_IRQ_EN1 (at 0xF9886018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER1"
        group.long 0x201C--0x201F "BAM_P_TIMER1 (at 0xF988601C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL1"
        group.long 0x2020--0x2023 "BAM_P_TIMER_CTRL1 (at 0xF9886020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND1"
        group.long 0x2024--0x2027 "BAM_P_PRDCR_SDBND1 (at 0xF9886024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND1"
        group.long 0x2028--0x202B "BAM_P_CNSMR_SDBND1 (at 0xF9886028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR1"
        group.long 0x282C--0x282F "BAM_P_EVNT_DEST_ADDR1 (at 0xF988682C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG1"
        group.long 0x2818--0x281B "BAM_P_EVNT_REG1 (at 0xF9886818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS1"
        group.long 0x2800--0x2803 "BAM_P_SW_OFSTS1 (at 0xF9886800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR1"
        group.long 0x2824--0x2827 "BAM_P_DATA_FIFO_ADDR1 (at 0xF9886824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR1"
        group.long 0x281C--0x281F "BAM_P_DESC_FIFO_ADDR1 (at 0xF988681C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD1"
        group.long 0x2828--0x282B "BAM_P_EVNT_GEN_TRSHLD1 (at 0xF9886828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES1"
        group.long 0x2820--0x2823 "BAM_P_FIFO_SIZES1 (at 0xF9886820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_1"
        group.long 0x2834--0x2837 "BAM_P_RETR_CNTXT_1 (at 0xF9886834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_1"
        group.long 0x2838--0x283B "BAM_P_SI_CNTXT_1 (at 0xF9886838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_1"
        group.long 0x2830--0x2833 "BAM_P_DF_CNTXT_1 (at 0xF9886830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_1"
        group.long 0x2804--0x2807 "BAM_P_AU_PSM_CNTXT_1_1 (at 0xF9886804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_1"
        group.long 0x2808--0x280B "BAM_P_PSM_CNTXT_2_1 (at 0xF9886808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_1"
        group.long 0x280C--0x280F "BAM_P_PSM_CNTXT_3_1 (at 0xF988680C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_1"
        group.long 0x2810--0x2813 "BAM_P_PSM_CNTXT_4_1 (at 0xF9886810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_1"
        group.long 0x2814--0x2817 "BAM_P_PSM_CNTXT_5_1 (at 0xF9886814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 1
tree.end
tree "Pipe 2"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL2"
        group.long 0x3000--0x3003 "BAM_P_CTRL2 (at 0xF9887000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST2"
        group.long 0x3004--0x3007 "BAM_P_RST2 (at 0xF9887004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT2"
        group.long 0x3008--0x300B "BAM_P_HALT2 (at 0xF9887008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG2"
        group.long 0x3030--0x3033 "BAM_P_TRUST_REG2 (at 0xF9887030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS2"
        group.long 0x3010--0x3013 "BAM_P_IRQ_STTS2 (at 0xF9887010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR2"
        group.long 0x3014--0x3017 "BAM_P_IRQ_CLR2 (at 0xF9887014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN2"
        group.long 0x3018--0x301B "BAM_P_IRQ_EN2 (at 0xF9887018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER2"
        group.long 0x301C--0x301F "BAM_P_TIMER2 (at 0xF988701C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL2"
        group.long 0x3020--0x3023 "BAM_P_TIMER_CTRL2 (at 0xF9887020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND2"
        group.long 0x3024--0x3027 "BAM_P_PRDCR_SDBND2 (at 0xF9887024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND2"
        group.long 0x3028--0x302B "BAM_P_CNSMR_SDBND2 (at 0xF9887028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR2"
        group.long 0x382C--0x382F "BAM_P_EVNT_DEST_ADDR2 (at 0xF988782C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG2"
        group.long 0x3818--0x381B "BAM_P_EVNT_REG2 (at 0xF9887818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS2"
        group.long 0x3800--0x3803 "BAM_P_SW_OFSTS2 (at 0xF9887800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR2"
        group.long 0x3824--0x3827 "BAM_P_DATA_FIFO_ADDR2 (at 0xF9887824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR2"
        group.long 0x381C--0x381F "BAM_P_DESC_FIFO_ADDR2 (at 0xF988781C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD2"
        group.long 0x3828--0x382B "BAM_P_EVNT_GEN_TRSHLD2 (at 0xF9887828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES2"
        group.long 0x3820--0x3823 "BAM_P_FIFO_SIZES2 (at 0xF9887820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_2"
        group.long 0x3834--0x3837 "BAM_P_RETR_CNTXT_2 (at 0xF9887834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_2"
        group.long 0x3838--0x383B "BAM_P_SI_CNTXT_2 (at 0xF9887838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_2"
        group.long 0x3830--0x3833 "BAM_P_DF_CNTXT_2 (at 0xF9887830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_2"
        group.long 0x3804--0x3807 "BAM_P_AU_PSM_CNTXT_1_2 (at 0xF9887804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_2"
        group.long 0x3808--0x380B "BAM_P_PSM_CNTXT_2_2 (at 0xF9887808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_2"
        group.long 0x380C--0x380F "BAM_P_PSM_CNTXT_3_2 (at 0xF988780C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_2"
        group.long 0x3810--0x3813 "BAM_P_PSM_CNTXT_4_2 (at 0xF9887810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_2"
        group.long 0x3814--0x3817 "BAM_P_PSM_CNTXT_5_2 (at 0xF9887814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 2
tree.end
tree "Pipe 3"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL3"
        group.long 0x4000--0x4003 "BAM_P_CTRL3 (at 0xF9888000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST3"
        group.long 0x4004--0x4007 "BAM_P_RST3 (at 0xF9888004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT3"
        group.long 0x4008--0x400B "BAM_P_HALT3 (at 0xF9888008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG3"
        group.long 0x4030--0x4033 "BAM_P_TRUST_REG3 (at 0xF9888030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS3"
        group.long 0x4010--0x4013 "BAM_P_IRQ_STTS3 (at 0xF9888010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR3"
        group.long 0x4014--0x4017 "BAM_P_IRQ_CLR3 (at 0xF9888014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN3"
        group.long 0x4018--0x401B "BAM_P_IRQ_EN3 (at 0xF9888018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER3"
        group.long 0x401C--0x401F "BAM_P_TIMER3 (at 0xF988801C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL3"
        group.long 0x4020--0x4023 "BAM_P_TIMER_CTRL3 (at 0xF9888020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND3"
        group.long 0x4024--0x4027 "BAM_P_PRDCR_SDBND3 (at 0xF9888024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND3"
        group.long 0x4028--0x402B "BAM_P_CNSMR_SDBND3 (at 0xF9888028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR3"
        group.long 0x482C--0x482F "BAM_P_EVNT_DEST_ADDR3 (at 0xF988882C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG3"
        group.long 0x4818--0x481B "BAM_P_EVNT_REG3 (at 0xF9888818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS3"
        group.long 0x4800--0x4803 "BAM_P_SW_OFSTS3 (at 0xF9888800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR3"
        group.long 0x4824--0x4827 "BAM_P_DATA_FIFO_ADDR3 (at 0xF9888824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR3"
        group.long 0x481C--0x481F "BAM_P_DESC_FIFO_ADDR3 (at 0xF988881C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD3"
        group.long 0x4828--0x482B "BAM_P_EVNT_GEN_TRSHLD3 (at 0xF9888828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES3"
        group.long 0x4820--0x4823 "BAM_P_FIFO_SIZES3 (at 0xF9888820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_3"
        group.long 0x4834--0x4837 "BAM_P_RETR_CNTXT_3 (at 0xF9888834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_3"
        group.long 0x4838--0x483B "BAM_P_SI_CNTXT_3 (at 0xF9888838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_3"
        group.long 0x4830--0x4833 "BAM_P_DF_CNTXT_3 (at 0xF9888830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_3"
        group.long 0x4804--0x4807 "BAM_P_AU_PSM_CNTXT_1_3 (at 0xF9888804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_3"
        group.long 0x4808--0x480B "BAM_P_PSM_CNTXT_2_3 (at 0xF9888808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_3"
        group.long 0x480C--0x480F "BAM_P_PSM_CNTXT_3_3 (at 0xF988880C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_3"
        group.long 0x4810--0x4813 "BAM_P_PSM_CNTXT_4_3 (at 0xF9888810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_3"
        group.long 0x4814--0x4817 "BAM_P_PSM_CNTXT_5_3 (at 0xF9888814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 3
tree.end
tree "Pipe 4"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL4"
        group.long 0x5000--0x5003 "BAM_P_CTRL4 (at 0xF9889000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST4"
        group.long 0x5004--0x5007 "BAM_P_RST4 (at 0xF9889004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT4"
        group.long 0x5008--0x500B "BAM_P_HALT4 (at 0xF9889008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG4"
        group.long 0x5030--0x5033 "BAM_P_TRUST_REG4 (at 0xF9889030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS4"
        group.long 0x5010--0x5013 "BAM_P_IRQ_STTS4 (at 0xF9889010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR4"
        group.long 0x5014--0x5017 "BAM_P_IRQ_CLR4 (at 0xF9889014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN4"
        group.long 0x5018--0x501B "BAM_P_IRQ_EN4 (at 0xF9889018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER4"
        group.long 0x501C--0x501F "BAM_P_TIMER4 (at 0xF988901C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL4"
        group.long 0x5020--0x5023 "BAM_P_TIMER_CTRL4 (at 0xF9889020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND4"
        group.long 0x5024--0x5027 "BAM_P_PRDCR_SDBND4 (at 0xF9889024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND4"
        group.long 0x5028--0x502B "BAM_P_CNSMR_SDBND4 (at 0xF9889028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR4"
        group.long 0x582C--0x582F "BAM_P_EVNT_DEST_ADDR4 (at 0xF988982C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG4"
        group.long 0x5818--0x581B "BAM_P_EVNT_REG4 (at 0xF9889818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS4"
        group.long 0x5800--0x5803 "BAM_P_SW_OFSTS4 (at 0xF9889800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR4"
        group.long 0x5824--0x5827 "BAM_P_DATA_FIFO_ADDR4 (at 0xF9889824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR4"
        group.long 0x581C--0x581F "BAM_P_DESC_FIFO_ADDR4 (at 0xF988981C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD4"
        group.long 0x5828--0x582B "BAM_P_EVNT_GEN_TRSHLD4 (at 0xF9889828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES4"
        group.long 0x5820--0x5823 "BAM_P_FIFO_SIZES4 (at 0xF9889820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_4"
        group.long 0x5834--0x5837 "BAM_P_RETR_CNTXT_4 (at 0xF9889834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_4"
        group.long 0x5838--0x583B "BAM_P_SI_CNTXT_4 (at 0xF9889838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_4"
        group.long 0x5830--0x5833 "BAM_P_DF_CNTXT_4 (at 0xF9889830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_4"
        group.long 0x5804--0x5807 "BAM_P_AU_PSM_CNTXT_1_4 (at 0xF9889804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_4"
        group.long 0x5808--0x580B "BAM_P_PSM_CNTXT_2_4 (at 0xF9889808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_4"
        group.long 0x580C--0x580F "BAM_P_PSM_CNTXT_3_4 (at 0xF988980C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_4"
        group.long 0x5810--0x5813 "BAM_P_PSM_CNTXT_4_4 (at 0xF9889810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_4"
        group.long 0x5814--0x5817 "BAM_P_PSM_CNTXT_5_4 (at 0xF9889814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 4
tree.end
tree "Pipe 5"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL5"
        group.long 0x6000--0x6003 "BAM_P_CTRL5 (at 0xF988A000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST5"
        group.long 0x6004--0x6007 "BAM_P_RST5 (at 0xF988A004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT5"
        group.long 0x6008--0x600B "BAM_P_HALT5 (at 0xF988A008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG5"
        group.long 0x6030--0x6033 "BAM_P_TRUST_REG5 (at 0xF988A030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS5"
        group.long 0x6010--0x6013 "BAM_P_IRQ_STTS5 (at 0xF988A010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR5"
        group.long 0x6014--0x6017 "BAM_P_IRQ_CLR5 (at 0xF988A014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN5"
        group.long 0x6018--0x601B "BAM_P_IRQ_EN5 (at 0xF988A018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER5"
        group.long 0x601C--0x601F "BAM_P_TIMER5 (at 0xF988A01C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL5"
        group.long 0x6020--0x6023 "BAM_P_TIMER_CTRL5 (at 0xF988A020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND5"
        group.long 0x6024--0x6027 "BAM_P_PRDCR_SDBND5 (at 0xF988A024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND5"
        group.long 0x6028--0x602B "BAM_P_CNSMR_SDBND5 (at 0xF988A028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR5"
        group.long 0x682C--0x682F "BAM_P_EVNT_DEST_ADDR5 (at 0xF988A82C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG5"
        group.long 0x6818--0x681B "BAM_P_EVNT_REG5 (at 0xF988A818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS5"
        group.long 0x6800--0x6803 "BAM_P_SW_OFSTS5 (at 0xF988A800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR5"
        group.long 0x6824--0x6827 "BAM_P_DATA_FIFO_ADDR5 (at 0xF988A824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR5"
        group.long 0x681C--0x681F "BAM_P_DESC_FIFO_ADDR5 (at 0xF988A81C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD5"
        group.long 0x6828--0x682B "BAM_P_EVNT_GEN_TRSHLD5 (at 0xF988A828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES5"
        group.long 0x6820--0x6823 "BAM_P_FIFO_SIZES5 (at 0xF988A820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_5"
        group.long 0x6834--0x6837 "BAM_P_RETR_CNTXT_5 (at 0xF988A834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_5"
        group.long 0x6838--0x683B "BAM_P_SI_CNTXT_5 (at 0xF988A838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_5"
        group.long 0x6830--0x6833 "BAM_P_DF_CNTXT_5 (at 0xF988A830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_5"
        group.long 0x6804--0x6807 "BAM_P_AU_PSM_CNTXT_1_5 (at 0xF988A804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_5"
        group.long 0x6808--0x680B "BAM_P_PSM_CNTXT_2_5 (at 0xF988A808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_5"
        group.long 0x680C--0x680F "BAM_P_PSM_CNTXT_3_5 (at 0xF988A80C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_5"
        group.long 0x6810--0x6813 "BAM_P_PSM_CNTXT_4_5 (at 0xF988A810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_5"
        group.long 0x6814--0x6817 "BAM_P_PSM_CNTXT_5_5 (at 0xF988A814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 5
tree.end
tree.end
;Block Per Data Ends

base ad:0xF98C4000
tree "SDC4"
tree "BAM Control Registers"
      tree "BAM_CTRL"
        group.long 0x0--0x3 "BAM_CTRL (at 0xF98C4000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x13 " [   19]   CACHE_MISS_ERR_RESP_EN                   = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11--0x12 " [18:17]   LOCAL_CLK_GATING                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   IBC_DISABLE                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0xF " [   15]   BAM_CACHED_DESC_STORE                    = "  "0,1"
        textline ""
        bitfld.long 0x0 0xD--0xE " [14:13]   BAM_DESC_CACHE_SEL                       = "  "0,1,2,3"
        textline ""
        hexmask.long.word 0x0 0x5--0xB 1  " [11:05]   BAM_TESTBUS_SEL                          = " 
        textline ""
        bitfld.long 0x0 0x4 " [   04]   BAM_EN_ACCUM                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_EN                                   = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   BAM_SW_RST                               = "  "0,1"
        textline ""
      tree.end
      tree "BAM_REVISION"
        group.long 0x4--0x7 "BAM_REVISION (at 0xF98C4004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x18--0x1F 1  " [31:24]   INACTIV_TMR_BASE                         = " 
        textline ""
        bitfld.long 0x0 0x17 " [   23]   CMD_DESC_EN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15--0x16 " [22:21]   DESC_CACHE_DEPTH                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   NUM_INACTIV_TMRS                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x13 " [   19]   INACTIV_TMRS_EXST                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x12 " [   18]   HIGH_FREQUENCY_BAM                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11 " [   17]   BAM_HAS_NO_BYPASS                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   SECURED                                  = "  "0,1"
        textline ""
        bitfld.long 0x0 0xF " [   15]   USE_VMIDMT                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0xE " [   14]   AXI_ACTIVE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0xD " [   13]   CE_BUFFER_SIZE                           = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x8--0xB 1  " [11:08]   NUM_EES                                  = " 
        textline ""
        hexmask.long.word 0x0 0x0--0x7 1  " [07:00]   REVISION                                 = " 
        textline ""
      tree.end
      tree "BAM_SW_VERSION"
        group.long 0x80--0x83 "BAM_SW_VERSION (at 0xF98C4080) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x1C--0x1F 1  " [31:28]   MAJOR                                    = " 
        textline ""
        hexmask.long.word 0x0 0x10--0x1B 1  " [27:16]   MINOR                                    = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   STEP                                     = " 
        textline ""
      tree.end
      tree "BAM_NUM_PIPES"
        group.long 0x3C--0x3F "BAM_NUM_PIPES (at 0xF98C403C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x18--0x1F 1  " [31:24]   BAM_NON_PIPE_GRP                         = " 
        textline ""
        hexmask.long.word 0x0 0x10--0x17 1  " [23:16]   PERIPH_NON_PIPE_GRP                      = " 
        textline ""
        hexmask.long.word 0x0 0x0--0x7 1  " [07:00]   BAM_NUM_PIPES                            = " 
        textline ""
      tree.end
      tree "BAM_TIMER"
        group.long 0x40--0x43 "BAM_TIMER (at 0xF98C4040) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   TIMER                                    = " 
        textline ""
      tree.end
      tree "BAM_TIMER_CTRL"
        group.long 0x44--0x47 "BAM_TIMER_CTRL (at 0xF98C4044) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   TIMER_RST                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   TIMER_RUN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   TIMER_MODE                               = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   TIMER_TRSHLD                             = " 
        textline ""
      tree.end
      tree "BAM_DESC_CNT_TRSHLD"
        group.long 0x8--0xB "BAM_DESC_CNT_TRSHLD (at 0xF98C4008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   CNT_TRSHLD                               = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS"
        group.long 0xC--0xF "BAM_IRQ_SRCS (at 0xF98C400C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK"
        group.long 0x10--0x13 "BAM_IRQ_SRCS_MSK (at 0xF98C4010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED"
        group.long 0x30--0x33 "BAM_IRQ_SRCS_UNMASKED (at 0xF98C4030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_STTS"
        group.long 0x14--0x17 "BAM_IRQ_STTS (at 0xF98C4014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x4 " [   04]   BAM_TIMER_IRQ                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   BAM_EMPTY_IRQ                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_ERROR_IRQ                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_HRESP_ERR_IRQ                        = "  "0,1"
        textline ""
      tree.end
      tree "BAM_IRQ_CLR"
        group.long 0x18--0x1B "BAM_IRQ_CLR (at 0xF98C4018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x4 " [   04]   BAM_TIMER_CLR                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   BAM_EMPTY_CLR                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_ERROR_CLR                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_HRESP_ERR_CLR                        = "  "0,1"
        textline ""
      tree.end
      tree "BAM_IRQ_EN"
        group.long 0x1C--0x1F "BAM_IRQ_EN (at 0xF98C401C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x4 " [   04]   BAM_TIMER_EN                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   BAM_EMPTY_EN                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_ERROR_EN                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_HRESP_ERR_EN                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_AHB_MASTER_ERR_CTRLS"
        group.long 0x24--0x27 "BAM_AHB_MASTER_ERR_CTRLS (at 0xF98C4024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x12--0x16 1  " [22:18]   BAM_ERR_HVMID                            = " 
        textline ""
        bitfld.long 0x0 0x11 " [   17]   BAM_ERR_DIRECT_MODE                      = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0xC--0x10 1  " [16:12]   BAM_ERR_HCID                             = " 
        textline ""
        hexmask.long.word 0x0 0x8--0xB 1  " [11:08]   BAM_ERR_HPROT                            = " 
        textline ""
        bitfld.long 0x0 0x5--0x7 " [07:05]   BAM_ERR_HBURST                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x3--0x4 " [04:03]   BAM_ERR_HSIZE                            = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_ERR_HWRITE                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0--0x1 " [01:00]   BAM_ERR_HTRANS                           = "  "0,1,2,3"
        textline ""
      tree.end
      tree "BAM_AHB_MASTER_ERR_ADDR"
        group.long 0x28--0x2B "BAM_AHB_MASTER_ERR_ADDR (at 0xF98C4028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   BAM_ERR_ADDR                             = " 
        textline ""
      tree.end
      tree "BAM_AHB_MASTER_ERR_DATA"
        group.long 0x2C--0x2F "BAM_AHB_MASTER_ERR_DATA (at 0xF98C402C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   BAM_ERR_DATA                             = " 
        textline ""
      tree.end
      tree "BAM_TRUST_REG"
        group.long 0x70--0x73 "BAM_TRUST_REG (at 0xF98C4070) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0xD " [   13]   LOCK_EE_CTRL                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_VMID                                 = " 
        textline ""
        bitfld.long 0x0 0x7 " [   07]   BAM_RST_BLOCK                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_EE                                   = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_TEST_BUS_SEL"
        group.long 0x74--0x77 "BAM_TEST_BUS_SEL (at 0xF98C4074) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x15 " [   21]   SW_EVENTS_ZERO                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x13--0x14 " [20:19]   SW_EVENTS_SEL                            = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x12 " [   18]   BAM_DATA_ERASE                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11 " [   17]   BAM_DATA_FLUSH                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   BAM_CLK_ALWAYS_ON                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x0--0x6 1  " [06:00]   BAM_TESTBUS_SEL                          = " 
        textline ""
      tree.end
      tree "BAM_TEST_BUS_REG"
        group.long 0x78--0x7B "BAM_TEST_BUS_REG (at 0xF98C4078) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   BAM_TESTBUS_REG                          = " 
        textline ""
      tree.end
      tree "BAM_CNFG_BITS"
        group.long 0x7C--0x7F "BAM_CNFG_BITS (at 0xF98C407C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1C " [   28]   BAM_ZLT_W_CD_SUPPORT                     = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1B " [   27]   BAM_CD_ENABLE                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1A " [   26]   BAM_AU_ACCUMED                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x19 " [   25]   BAM_PSM_P_HD_DATA                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_REG_P_EN                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_WB_DSC_AVL_P_RST                     = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_WB_RETR_SVPNT                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_WB_CSW_ACK_IDL                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_WB_BLK_CSW                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x13 " [   19]   BAM_WB_P_RES                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x12 " [   18]   BAM_SI_P_RES                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11 " [   17]   BAM_AU_P_RES                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   BAM_PSM_P_RES                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0xF " [   15]   BAM_PSM_CSW_REQ                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0xE " [   14]   BAM_SB_CLK_REQ                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0xD " [   13]   BAM_IBC_DISABLE                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0xC " [   12]   BAM_NO_EXT_P_RST                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0xB " [   11]   BAM_FULL_PIPE                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   BAM_ADML_SYNC_BRIDGE                     = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_PIPE_CNFG                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_ADML_DEEP_CONS_FIFO                  = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   BAM_ADML_INCR4_EN_N                      = "  "0,1"
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE0"
        group.long 0x800--0x803 "BAM_IRQ_SRCS_EE0 (at 0xF98C4800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE1"
        group.long 0x880--0x883 "BAM_IRQ_SRCS_EE1 (at 0xF98C4880) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE2"
        group.long 0x900--0x903 "BAM_IRQ_SRCS_EE2 (at 0xF98C4900) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE3"
        group.long 0x980--0x983 "BAM_IRQ_SRCS_EE3 (at 0xF98C4980) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE4"
        group.long 0xA00--0xA03 "BAM_IRQ_SRCS_EE4 (at 0xF98C4A00) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE5"
        group.long 0xA80--0xA83 "BAM_IRQ_SRCS_EE5 (at 0xF98C4A80) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE6"
        group.long 0xB00--0xB03 "BAM_IRQ_SRCS_EE6 (at 0xF98C4B00) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE7"
        group.long 0xB80--0xB83 "BAM_IRQ_SRCS_EE7 (at 0xF98C4B80) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE0"
        group.long 0x804--0x807 "BAM_IRQ_SRCS_MSK_EE0 (at 0xF98C4804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE1"
        group.long 0x884--0x887 "BAM_IRQ_SRCS_MSK_EE1 (at 0xF98C4884) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE2"
        group.long 0x904--0x907 "BAM_IRQ_SRCS_MSK_EE2 (at 0xF98C4904) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE3"
        group.long 0x984--0x987 "BAM_IRQ_SRCS_MSK_EE3 (at 0xF98C4984) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE4"
        group.long 0xA04--0xA07 "BAM_IRQ_SRCS_MSK_EE4 (at 0xF98C4A04) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE5"
        group.long 0xA84--0xA87 "BAM_IRQ_SRCS_MSK_EE5 (at 0xF98C4A84) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE6"
        group.long 0xB04--0xB07 "BAM_IRQ_SRCS_MSK_EE6 (at 0xF98C4B04) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE7"
        group.long 0xB84--0xB87 "BAM_IRQ_SRCS_MSK_EE7 (at 0xF98C4B84) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE0"
        group.long 0x808--0x80B "BAM_IRQ_SRCS_UNMASKED_EE0 (at 0xF98C4808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE1"
        group.long 0x888--0x88B "BAM_IRQ_SRCS_UNMASKED_EE1 (at 0xF98C4888) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE2"
        group.long 0x908--0x90B "BAM_IRQ_SRCS_UNMASKED_EE2 (at 0xF98C4908) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE3"
        group.long 0x988--0x98B "BAM_IRQ_SRCS_UNMASKED_EE3 (at 0xF98C4988) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE4"
        group.long 0xA08--0xA0B "BAM_IRQ_SRCS_UNMASKED_EE4 (at 0xF98C4A08) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE5"
        group.long 0xA88--0xA8B "BAM_IRQ_SRCS_UNMASKED_EE5 (at 0xF98C4A88) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE6"
        group.long 0xB08--0xB0B "BAM_IRQ_SRCS_UNMASKED_EE6 (at 0xF98C4B08) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE7"
        group.long 0xB88--0xB8B "BAM_IRQ_SRCS_UNMASKED_EE7 (at 0xF98C4B88) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
;End of BAM Control Registers
tree.end
tree "Pipe 0"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL0"
        group.long 0x1000--0x1003 "BAM_P_CTRL0 (at 0xF98C5000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST0"
        group.long 0x1004--0x1007 "BAM_P_RST0 (at 0xF98C5004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT0"
        group.long 0x1008--0x100B "BAM_P_HALT0 (at 0xF98C5008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG0"
        group.long 0x1030--0x1033 "BAM_P_TRUST_REG0 (at 0xF98C5030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS0"
        group.long 0x1010--0x1013 "BAM_P_IRQ_STTS0 (at 0xF98C5010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR0"
        group.long 0x1014--0x1017 "BAM_P_IRQ_CLR0 (at 0xF98C5014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN0"
        group.long 0x1018--0x101B "BAM_P_IRQ_EN0 (at 0xF98C5018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER0"
        group.long 0x101C--0x101F "BAM_P_TIMER0 (at 0xF98C501C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL0"
        group.long 0x1020--0x1023 "BAM_P_TIMER_CTRL0 (at 0xF98C5020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND0"
        group.long 0x1024--0x1027 "BAM_P_PRDCR_SDBND0 (at 0xF98C5024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND0"
        group.long 0x1028--0x102B "BAM_P_CNSMR_SDBND0 (at 0xF98C5028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR0"
        group.long 0x182C--0x182F "BAM_P_EVNT_DEST_ADDR0 (at 0xF98C582C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG0"
        group.long 0x1818--0x181B "BAM_P_EVNT_REG0 (at 0xF98C5818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS0"
        group.long 0x1800--0x1803 "BAM_P_SW_OFSTS0 (at 0xF98C5800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR0"
        group.long 0x1824--0x1827 "BAM_P_DATA_FIFO_ADDR0 (at 0xF98C5824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR0"
        group.long 0x181C--0x181F "BAM_P_DESC_FIFO_ADDR0 (at 0xF98C581C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD0"
        group.long 0x1828--0x182B "BAM_P_EVNT_GEN_TRSHLD0 (at 0xF98C5828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES0"
        group.long 0x1820--0x1823 "BAM_P_FIFO_SIZES0 (at 0xF98C5820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_0"
        group.long 0x1834--0x1837 "BAM_P_RETR_CNTXT_0 (at 0xF98C5834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_0"
        group.long 0x1838--0x183B "BAM_P_SI_CNTXT_0 (at 0xF98C5838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_0"
        group.long 0x1830--0x1833 "BAM_P_DF_CNTXT_0 (at 0xF98C5830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_0"
        group.long 0x1804--0x1807 "BAM_P_AU_PSM_CNTXT_1_0 (at 0xF98C5804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_0"
        group.long 0x1808--0x180B "BAM_P_PSM_CNTXT_2_0 (at 0xF98C5808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_0"
        group.long 0x180C--0x180F "BAM_P_PSM_CNTXT_3_0 (at 0xF98C580C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_0"
        group.long 0x1810--0x1813 "BAM_P_PSM_CNTXT_4_0 (at 0xF98C5810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_0"
        group.long 0x1814--0x1817 "BAM_P_PSM_CNTXT_5_0 (at 0xF98C5814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 0
tree.end
tree "Pipe 1"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL1"
        group.long 0x2000--0x2003 "BAM_P_CTRL1 (at 0xF98C6000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST1"
        group.long 0x2004--0x2007 "BAM_P_RST1 (at 0xF98C6004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT1"
        group.long 0x2008--0x200B "BAM_P_HALT1 (at 0xF98C6008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG1"
        group.long 0x2030--0x2033 "BAM_P_TRUST_REG1 (at 0xF98C6030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS1"
        group.long 0x2010--0x2013 "BAM_P_IRQ_STTS1 (at 0xF98C6010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR1"
        group.long 0x2014--0x2017 "BAM_P_IRQ_CLR1 (at 0xF98C6014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN1"
        group.long 0x2018--0x201B "BAM_P_IRQ_EN1 (at 0xF98C6018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER1"
        group.long 0x201C--0x201F "BAM_P_TIMER1 (at 0xF98C601C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL1"
        group.long 0x2020--0x2023 "BAM_P_TIMER_CTRL1 (at 0xF98C6020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND1"
        group.long 0x2024--0x2027 "BAM_P_PRDCR_SDBND1 (at 0xF98C6024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND1"
        group.long 0x2028--0x202B "BAM_P_CNSMR_SDBND1 (at 0xF98C6028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR1"
        group.long 0x282C--0x282F "BAM_P_EVNT_DEST_ADDR1 (at 0xF98C682C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG1"
        group.long 0x2818--0x281B "BAM_P_EVNT_REG1 (at 0xF98C6818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS1"
        group.long 0x2800--0x2803 "BAM_P_SW_OFSTS1 (at 0xF98C6800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR1"
        group.long 0x2824--0x2827 "BAM_P_DATA_FIFO_ADDR1 (at 0xF98C6824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR1"
        group.long 0x281C--0x281F "BAM_P_DESC_FIFO_ADDR1 (at 0xF98C681C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD1"
        group.long 0x2828--0x282B "BAM_P_EVNT_GEN_TRSHLD1 (at 0xF98C6828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES1"
        group.long 0x2820--0x2823 "BAM_P_FIFO_SIZES1 (at 0xF98C6820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_1"
        group.long 0x2834--0x2837 "BAM_P_RETR_CNTXT_1 (at 0xF98C6834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_1"
        group.long 0x2838--0x283B "BAM_P_SI_CNTXT_1 (at 0xF98C6838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_1"
        group.long 0x2830--0x2833 "BAM_P_DF_CNTXT_1 (at 0xF98C6830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_1"
        group.long 0x2804--0x2807 "BAM_P_AU_PSM_CNTXT_1_1 (at 0xF98C6804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_1"
        group.long 0x2808--0x280B "BAM_P_PSM_CNTXT_2_1 (at 0xF98C6808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_1"
        group.long 0x280C--0x280F "BAM_P_PSM_CNTXT_3_1 (at 0xF98C680C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_1"
        group.long 0x2810--0x2813 "BAM_P_PSM_CNTXT_4_1 (at 0xF98C6810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_1"
        group.long 0x2814--0x2817 "BAM_P_PSM_CNTXT_5_1 (at 0xF98C6814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 1
tree.end
tree "Pipe 2"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL2"
        group.long 0x3000--0x3003 "BAM_P_CTRL2 (at 0xF98C7000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST2"
        group.long 0x3004--0x3007 "BAM_P_RST2 (at 0xF98C7004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT2"
        group.long 0x3008--0x300B "BAM_P_HALT2 (at 0xF98C7008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG2"
        group.long 0x3030--0x3033 "BAM_P_TRUST_REG2 (at 0xF98C7030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS2"
        group.long 0x3010--0x3013 "BAM_P_IRQ_STTS2 (at 0xF98C7010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR2"
        group.long 0x3014--0x3017 "BAM_P_IRQ_CLR2 (at 0xF98C7014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN2"
        group.long 0x3018--0x301B "BAM_P_IRQ_EN2 (at 0xF98C7018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER2"
        group.long 0x301C--0x301F "BAM_P_TIMER2 (at 0xF98C701C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL2"
        group.long 0x3020--0x3023 "BAM_P_TIMER_CTRL2 (at 0xF98C7020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND2"
        group.long 0x3024--0x3027 "BAM_P_PRDCR_SDBND2 (at 0xF98C7024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND2"
        group.long 0x3028--0x302B "BAM_P_CNSMR_SDBND2 (at 0xF98C7028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR2"
        group.long 0x382C--0x382F "BAM_P_EVNT_DEST_ADDR2 (at 0xF98C782C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG2"
        group.long 0x3818--0x381B "BAM_P_EVNT_REG2 (at 0xF98C7818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS2"
        group.long 0x3800--0x3803 "BAM_P_SW_OFSTS2 (at 0xF98C7800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR2"
        group.long 0x3824--0x3827 "BAM_P_DATA_FIFO_ADDR2 (at 0xF98C7824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR2"
        group.long 0x381C--0x381F "BAM_P_DESC_FIFO_ADDR2 (at 0xF98C781C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD2"
        group.long 0x3828--0x382B "BAM_P_EVNT_GEN_TRSHLD2 (at 0xF98C7828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES2"
        group.long 0x3820--0x3823 "BAM_P_FIFO_SIZES2 (at 0xF98C7820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_2"
        group.long 0x3834--0x3837 "BAM_P_RETR_CNTXT_2 (at 0xF98C7834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_2"
        group.long 0x3838--0x383B "BAM_P_SI_CNTXT_2 (at 0xF98C7838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_2"
        group.long 0x3830--0x3833 "BAM_P_DF_CNTXT_2 (at 0xF98C7830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_2"
        group.long 0x3804--0x3807 "BAM_P_AU_PSM_CNTXT_1_2 (at 0xF98C7804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_2"
        group.long 0x3808--0x380B "BAM_P_PSM_CNTXT_2_2 (at 0xF98C7808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_2"
        group.long 0x380C--0x380F "BAM_P_PSM_CNTXT_3_2 (at 0xF98C780C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_2"
        group.long 0x3810--0x3813 "BAM_P_PSM_CNTXT_4_2 (at 0xF98C7810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_2"
        group.long 0x3814--0x3817 "BAM_P_PSM_CNTXT_5_2 (at 0xF98C7814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 2
tree.end
tree "Pipe 3"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL3"
        group.long 0x4000--0x4003 "BAM_P_CTRL3 (at 0xF98C8000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST3"
        group.long 0x4004--0x4007 "BAM_P_RST3 (at 0xF98C8004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT3"
        group.long 0x4008--0x400B "BAM_P_HALT3 (at 0xF98C8008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG3"
        group.long 0x4030--0x4033 "BAM_P_TRUST_REG3 (at 0xF98C8030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS3"
        group.long 0x4010--0x4013 "BAM_P_IRQ_STTS3 (at 0xF98C8010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR3"
        group.long 0x4014--0x4017 "BAM_P_IRQ_CLR3 (at 0xF98C8014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN3"
        group.long 0x4018--0x401B "BAM_P_IRQ_EN3 (at 0xF98C8018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER3"
        group.long 0x401C--0x401F "BAM_P_TIMER3 (at 0xF98C801C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL3"
        group.long 0x4020--0x4023 "BAM_P_TIMER_CTRL3 (at 0xF98C8020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND3"
        group.long 0x4024--0x4027 "BAM_P_PRDCR_SDBND3 (at 0xF98C8024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND3"
        group.long 0x4028--0x402B "BAM_P_CNSMR_SDBND3 (at 0xF98C8028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR3"
        group.long 0x482C--0x482F "BAM_P_EVNT_DEST_ADDR3 (at 0xF98C882C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG3"
        group.long 0x4818--0x481B "BAM_P_EVNT_REG3 (at 0xF98C8818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS3"
        group.long 0x4800--0x4803 "BAM_P_SW_OFSTS3 (at 0xF98C8800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR3"
        group.long 0x4824--0x4827 "BAM_P_DATA_FIFO_ADDR3 (at 0xF98C8824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR3"
        group.long 0x481C--0x481F "BAM_P_DESC_FIFO_ADDR3 (at 0xF98C881C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD3"
        group.long 0x4828--0x482B "BAM_P_EVNT_GEN_TRSHLD3 (at 0xF98C8828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES3"
        group.long 0x4820--0x4823 "BAM_P_FIFO_SIZES3 (at 0xF98C8820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_3"
        group.long 0x4834--0x4837 "BAM_P_RETR_CNTXT_3 (at 0xF98C8834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_3"
        group.long 0x4838--0x483B "BAM_P_SI_CNTXT_3 (at 0xF98C8838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_3"
        group.long 0x4830--0x4833 "BAM_P_DF_CNTXT_3 (at 0xF98C8830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_3"
        group.long 0x4804--0x4807 "BAM_P_AU_PSM_CNTXT_1_3 (at 0xF98C8804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_3"
        group.long 0x4808--0x480B "BAM_P_PSM_CNTXT_2_3 (at 0xF98C8808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_3"
        group.long 0x480C--0x480F "BAM_P_PSM_CNTXT_3_3 (at 0xF98C880C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_3"
        group.long 0x4810--0x4813 "BAM_P_PSM_CNTXT_4_3 (at 0xF98C8810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_3"
        group.long 0x4814--0x4817 "BAM_P_PSM_CNTXT_5_3 (at 0xF98C8814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 3
tree.end
tree "Pipe 4"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL4"
        group.long 0x5000--0x5003 "BAM_P_CTRL4 (at 0xF98C9000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST4"
        group.long 0x5004--0x5007 "BAM_P_RST4 (at 0xF98C9004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT4"
        group.long 0x5008--0x500B "BAM_P_HALT4 (at 0xF98C9008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG4"
        group.long 0x5030--0x5033 "BAM_P_TRUST_REG4 (at 0xF98C9030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS4"
        group.long 0x5010--0x5013 "BAM_P_IRQ_STTS4 (at 0xF98C9010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR4"
        group.long 0x5014--0x5017 "BAM_P_IRQ_CLR4 (at 0xF98C9014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN4"
        group.long 0x5018--0x501B "BAM_P_IRQ_EN4 (at 0xF98C9018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER4"
        group.long 0x501C--0x501F "BAM_P_TIMER4 (at 0xF98C901C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL4"
        group.long 0x5020--0x5023 "BAM_P_TIMER_CTRL4 (at 0xF98C9020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND4"
        group.long 0x5024--0x5027 "BAM_P_PRDCR_SDBND4 (at 0xF98C9024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND4"
        group.long 0x5028--0x502B "BAM_P_CNSMR_SDBND4 (at 0xF98C9028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR4"
        group.long 0x582C--0x582F "BAM_P_EVNT_DEST_ADDR4 (at 0xF98C982C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG4"
        group.long 0x5818--0x581B "BAM_P_EVNT_REG4 (at 0xF98C9818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS4"
        group.long 0x5800--0x5803 "BAM_P_SW_OFSTS4 (at 0xF98C9800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR4"
        group.long 0x5824--0x5827 "BAM_P_DATA_FIFO_ADDR4 (at 0xF98C9824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR4"
        group.long 0x581C--0x581F "BAM_P_DESC_FIFO_ADDR4 (at 0xF98C981C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD4"
        group.long 0x5828--0x582B "BAM_P_EVNT_GEN_TRSHLD4 (at 0xF98C9828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES4"
        group.long 0x5820--0x5823 "BAM_P_FIFO_SIZES4 (at 0xF98C9820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_4"
        group.long 0x5834--0x5837 "BAM_P_RETR_CNTXT_4 (at 0xF98C9834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_4"
        group.long 0x5838--0x583B "BAM_P_SI_CNTXT_4 (at 0xF98C9838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_4"
        group.long 0x5830--0x5833 "BAM_P_DF_CNTXT_4 (at 0xF98C9830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_4"
        group.long 0x5804--0x5807 "BAM_P_AU_PSM_CNTXT_1_4 (at 0xF98C9804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_4"
        group.long 0x5808--0x580B "BAM_P_PSM_CNTXT_2_4 (at 0xF98C9808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_4"
        group.long 0x580C--0x580F "BAM_P_PSM_CNTXT_3_4 (at 0xF98C980C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_4"
        group.long 0x5810--0x5813 "BAM_P_PSM_CNTXT_4_4 (at 0xF98C9810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_4"
        group.long 0x5814--0x5817 "BAM_P_PSM_CNTXT_5_4 (at 0xF98C9814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 4
tree.end
tree "Pipe 5"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL5"
        group.long 0x6000--0x6003 "BAM_P_CTRL5 (at 0xF98CA000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST5"
        group.long 0x6004--0x6007 "BAM_P_RST5 (at 0xF98CA004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT5"
        group.long 0x6008--0x600B "BAM_P_HALT5 (at 0xF98CA008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG5"
        group.long 0x6030--0x6033 "BAM_P_TRUST_REG5 (at 0xF98CA030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS5"
        group.long 0x6010--0x6013 "BAM_P_IRQ_STTS5 (at 0xF98CA010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR5"
        group.long 0x6014--0x6017 "BAM_P_IRQ_CLR5 (at 0xF98CA014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN5"
        group.long 0x6018--0x601B "BAM_P_IRQ_EN5 (at 0xF98CA018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER5"
        group.long 0x601C--0x601F "BAM_P_TIMER5 (at 0xF98CA01C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL5"
        group.long 0x6020--0x6023 "BAM_P_TIMER_CTRL5 (at 0xF98CA020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND5"
        group.long 0x6024--0x6027 "BAM_P_PRDCR_SDBND5 (at 0xF98CA024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND5"
        group.long 0x6028--0x602B "BAM_P_CNSMR_SDBND5 (at 0xF98CA028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR5"
        group.long 0x682C--0x682F "BAM_P_EVNT_DEST_ADDR5 (at 0xF98CA82C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG5"
        group.long 0x6818--0x681B "BAM_P_EVNT_REG5 (at 0xF98CA818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS5"
        group.long 0x6800--0x6803 "BAM_P_SW_OFSTS5 (at 0xF98CA800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR5"
        group.long 0x6824--0x6827 "BAM_P_DATA_FIFO_ADDR5 (at 0xF98CA824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR5"
        group.long 0x681C--0x681F "BAM_P_DESC_FIFO_ADDR5 (at 0xF98CA81C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD5"
        group.long 0x6828--0x682B "BAM_P_EVNT_GEN_TRSHLD5 (at 0xF98CA828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES5"
        group.long 0x6820--0x6823 "BAM_P_FIFO_SIZES5 (at 0xF98CA820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_5"
        group.long 0x6834--0x6837 "BAM_P_RETR_CNTXT_5 (at 0xF98CA834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_5"
        group.long 0x6838--0x683B "BAM_P_SI_CNTXT_5 (at 0xF98CA838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_5"
        group.long 0x6830--0x6833 "BAM_P_DF_CNTXT_5 (at 0xF98CA830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_5"
        group.long 0x6804--0x6807 "BAM_P_AU_PSM_CNTXT_1_5 (at 0xF98CA804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_5"
        group.long 0x6808--0x680B "BAM_P_PSM_CNTXT_2_5 (at 0xF98CA808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_5"
        group.long 0x680C--0x680F "BAM_P_PSM_CNTXT_3_5 (at 0xF98CA80C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_5"
        group.long 0x6810--0x6813 "BAM_P_PSM_CNTXT_4_5 (at 0xF98CA810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_5"
        group.long 0x6814--0x6817 "BAM_P_PSM_CNTXT_5_5 (at 0xF98CA814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 5
tree.end
tree.end
;Block Per Data Ends

base ad:0xF9904000
tree "BLSP1"
tree "BAM Control Registers"
      tree "BAM_CTRL"
        group.long 0x0--0x3 "BAM_CTRL (at 0xF9904000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x13 " [   19]   CACHE_MISS_ERR_RESP_EN                   = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11--0x12 " [18:17]   LOCAL_CLK_GATING                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   IBC_DISABLE                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0xF " [   15]   BAM_CACHED_DESC_STORE                    = "  "0,1"
        textline ""
        bitfld.long 0x0 0xD--0xE " [14:13]   BAM_DESC_CACHE_SEL                       = "  "0,1,2,3"
        textline ""
        hexmask.long.word 0x0 0x5--0xB 1  " [11:05]   BAM_TESTBUS_SEL                          = " 
        textline ""
        bitfld.long 0x0 0x4 " [   04]   BAM_EN_ACCUM                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_EN                                   = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   BAM_SW_RST                               = "  "0,1"
        textline ""
      tree.end
      tree "BAM_REVISION"
        group.long 0x4--0x7 "BAM_REVISION (at 0xF9904004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x18--0x1F 1  " [31:24]   INACTIV_TMR_BASE                         = " 
        textline ""
        bitfld.long 0x0 0x17 " [   23]   CMD_DESC_EN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15--0x16 " [22:21]   DESC_CACHE_DEPTH                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   NUM_INACTIV_TMRS                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x13 " [   19]   INACTIV_TMRS_EXST                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x12 " [   18]   HIGH_FREQUENCY_BAM                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11 " [   17]   BAM_HAS_NO_BYPASS                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   SECURED                                  = "  "0,1"
        textline ""
        bitfld.long 0x0 0xF " [   15]   USE_VMIDMT                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0xE " [   14]   AXI_ACTIVE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0xD " [   13]   CE_BUFFER_SIZE                           = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x8--0xB 1  " [11:08]   NUM_EES                                  = " 
        textline ""
        hexmask.long.word 0x0 0x0--0x7 1  " [07:00]   REVISION                                 = " 
        textline ""
      tree.end
      tree "BAM_SW_VERSION"
        group.long 0x80--0x83 "BAM_SW_VERSION (at 0xF9904080) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x1C--0x1F 1  " [31:28]   MAJOR                                    = " 
        textline ""
        hexmask.long.word 0x0 0x10--0x1B 1  " [27:16]   MINOR                                    = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   STEP                                     = " 
        textline ""
      tree.end
      tree "BAM_NUM_PIPES"
        group.long 0x3C--0x3F "BAM_NUM_PIPES (at 0xF990403C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x18--0x1F 1  " [31:24]   BAM_NON_PIPE_GRP                         = " 
        textline ""
        hexmask.long.word 0x0 0x10--0x17 1  " [23:16]   PERIPH_NON_PIPE_GRP                      = " 
        textline ""
        hexmask.long.word 0x0 0x0--0x7 1  " [07:00]   BAM_NUM_PIPES                            = " 
        textline ""
      tree.end
      tree "BAM_TIMER"
        group.long 0x40--0x43 "BAM_TIMER (at 0xF9904040) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   TIMER                                    = " 
        textline ""
      tree.end
      tree "BAM_TIMER_CTRL"
        group.long 0x44--0x47 "BAM_TIMER_CTRL (at 0xF9904044) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   TIMER_RST                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   TIMER_RUN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   TIMER_MODE                               = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   TIMER_TRSHLD                             = " 
        textline ""
      tree.end
      tree "BAM_DESC_CNT_TRSHLD"
        group.long 0x8--0xB "BAM_DESC_CNT_TRSHLD (at 0xF9904008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   CNT_TRSHLD                               = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS"
        group.long 0xC--0xF "BAM_IRQ_SRCS (at 0xF990400C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK"
        group.long 0x10--0x13 "BAM_IRQ_SRCS_MSK (at 0xF9904010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED"
        group.long 0x30--0x33 "BAM_IRQ_SRCS_UNMASKED (at 0xF9904030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_STTS"
        group.long 0x14--0x17 "BAM_IRQ_STTS (at 0xF9904014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x4 " [   04]   BAM_TIMER_IRQ                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   BAM_EMPTY_IRQ                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_ERROR_IRQ                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_HRESP_ERR_IRQ                        = "  "0,1"
        textline ""
      tree.end
      tree "BAM_IRQ_CLR"
        group.long 0x18--0x1B "BAM_IRQ_CLR (at 0xF9904018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x4 " [   04]   BAM_TIMER_CLR                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   BAM_EMPTY_CLR                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_ERROR_CLR                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_HRESP_ERR_CLR                        = "  "0,1"
        textline ""
      tree.end
      tree "BAM_IRQ_EN"
        group.long 0x1C--0x1F "BAM_IRQ_EN (at 0xF990401C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x4 " [   04]   BAM_TIMER_EN                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   BAM_EMPTY_EN                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_ERROR_EN                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_HRESP_ERR_EN                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_AHB_MASTER_ERR_CTRLS"
        group.long 0x24--0x27 "BAM_AHB_MASTER_ERR_CTRLS (at 0xF9904024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x12--0x16 1  " [22:18]   BAM_ERR_HVMID                            = " 
        textline ""
        bitfld.long 0x0 0x11 " [   17]   BAM_ERR_DIRECT_MODE                      = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0xC--0x10 1  " [16:12]   BAM_ERR_HCID                             = " 
        textline ""
        hexmask.long.word 0x0 0x8--0xB 1  " [11:08]   BAM_ERR_HPROT                            = " 
        textline ""
        bitfld.long 0x0 0x5--0x7 " [07:05]   BAM_ERR_HBURST                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x3--0x4 " [04:03]   BAM_ERR_HSIZE                            = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_ERR_HWRITE                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0--0x1 " [01:00]   BAM_ERR_HTRANS                           = "  "0,1,2,3"
        textline ""
      tree.end
      tree "BAM_AHB_MASTER_ERR_ADDR"
        group.long 0x28--0x2B "BAM_AHB_MASTER_ERR_ADDR (at 0xF9904028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   BAM_ERR_ADDR                             = " 
        textline ""
      tree.end
      tree "BAM_AHB_MASTER_ERR_DATA"
        group.long 0x2C--0x2F "BAM_AHB_MASTER_ERR_DATA (at 0xF990402C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   BAM_ERR_DATA                             = " 
        textline ""
      tree.end
      tree "BAM_TRUST_REG"
        group.long 0x70--0x73 "BAM_TRUST_REG (at 0xF9904070) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0xD " [   13]   LOCK_EE_CTRL                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_VMID                                 = " 
        textline ""
        bitfld.long 0x0 0x7 " [   07]   BAM_RST_BLOCK                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_EE                                   = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_TEST_BUS_SEL"
        group.long 0x74--0x77 "BAM_TEST_BUS_SEL (at 0xF9904074) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x15 " [   21]   SW_EVENTS_ZERO                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x13--0x14 " [20:19]   SW_EVENTS_SEL                            = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x12 " [   18]   BAM_DATA_ERASE                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11 " [   17]   BAM_DATA_FLUSH                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   BAM_CLK_ALWAYS_ON                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x0--0x6 1  " [06:00]   BAM_TESTBUS_SEL                          = " 
        textline ""
      tree.end
      tree "BAM_TEST_BUS_REG"
        group.long 0x78--0x7B "BAM_TEST_BUS_REG (at 0xF9904078) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   BAM_TESTBUS_REG                          = " 
        textline ""
      tree.end
      tree "BAM_CNFG_BITS"
        group.long 0x7C--0x7F "BAM_CNFG_BITS (at 0xF990407C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1C " [   28]   BAM_ZLT_W_CD_SUPPORT                     = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1B " [   27]   BAM_CD_ENABLE                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1A " [   26]   BAM_AU_ACCUMED                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x19 " [   25]   BAM_PSM_P_HD_DATA                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_REG_P_EN                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_WB_DSC_AVL_P_RST                     = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_WB_RETR_SVPNT                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_WB_CSW_ACK_IDL                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_WB_BLK_CSW                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x13 " [   19]   BAM_WB_P_RES                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x12 " [   18]   BAM_SI_P_RES                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11 " [   17]   BAM_AU_P_RES                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   BAM_PSM_P_RES                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0xF " [   15]   BAM_PSM_CSW_REQ                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0xE " [   14]   BAM_SB_CLK_REQ                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0xD " [   13]   BAM_IBC_DISABLE                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0xC " [   12]   BAM_NO_EXT_P_RST                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0xB " [   11]   BAM_FULL_PIPE                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   BAM_ADML_SYNC_BRIDGE                     = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_PIPE_CNFG                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_ADML_DEEP_CONS_FIFO                  = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   BAM_ADML_INCR4_EN_N                      = "  "0,1"
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE0"
        group.long 0x800--0x803 "BAM_IRQ_SRCS_EE0 (at 0xF9904800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE1"
        group.long 0x880--0x883 "BAM_IRQ_SRCS_EE1 (at 0xF9904880) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE2"
        group.long 0x900--0x903 "BAM_IRQ_SRCS_EE2 (at 0xF9904900) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE3"
        group.long 0x980--0x983 "BAM_IRQ_SRCS_EE3 (at 0xF9904980) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE4"
        group.long 0xA00--0xA03 "BAM_IRQ_SRCS_EE4 (at 0xF9904A00) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE5"
        group.long 0xA80--0xA83 "BAM_IRQ_SRCS_EE5 (at 0xF9904A80) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE6"
        group.long 0xB00--0xB03 "BAM_IRQ_SRCS_EE6 (at 0xF9904B00) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE7"
        group.long 0xB80--0xB83 "BAM_IRQ_SRCS_EE7 (at 0xF9904B80) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE0"
        group.long 0x804--0x807 "BAM_IRQ_SRCS_MSK_EE0 (at 0xF9904804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE1"
        group.long 0x884--0x887 "BAM_IRQ_SRCS_MSK_EE1 (at 0xF9904884) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE2"
        group.long 0x904--0x907 "BAM_IRQ_SRCS_MSK_EE2 (at 0xF9904904) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE3"
        group.long 0x984--0x987 "BAM_IRQ_SRCS_MSK_EE3 (at 0xF9904984) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE4"
        group.long 0xA04--0xA07 "BAM_IRQ_SRCS_MSK_EE4 (at 0xF9904A04) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE5"
        group.long 0xA84--0xA87 "BAM_IRQ_SRCS_MSK_EE5 (at 0xF9904A84) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE6"
        group.long 0xB04--0xB07 "BAM_IRQ_SRCS_MSK_EE6 (at 0xF9904B04) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE7"
        group.long 0xB84--0xB87 "BAM_IRQ_SRCS_MSK_EE7 (at 0xF9904B84) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE0"
        group.long 0x808--0x80B "BAM_IRQ_SRCS_UNMASKED_EE0 (at 0xF9904808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE1"
        group.long 0x888--0x88B "BAM_IRQ_SRCS_UNMASKED_EE1 (at 0xF9904888) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE2"
        group.long 0x908--0x90B "BAM_IRQ_SRCS_UNMASKED_EE2 (at 0xF9904908) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE3"
        group.long 0x988--0x98B "BAM_IRQ_SRCS_UNMASKED_EE3 (at 0xF9904988) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE4"
        group.long 0xA08--0xA0B "BAM_IRQ_SRCS_UNMASKED_EE4 (at 0xF9904A08) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE5"
        group.long 0xA88--0xA8B "BAM_IRQ_SRCS_UNMASKED_EE5 (at 0xF9904A88) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE6"
        group.long 0xB08--0xB0B "BAM_IRQ_SRCS_UNMASKED_EE6 (at 0xF9904B08) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE7"
        group.long 0xB88--0xB8B "BAM_IRQ_SRCS_UNMASKED_EE7 (at 0xF9904B88) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
;End of BAM Control Registers
tree.end
tree "Pipe 0"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL0"
        group.long 0x1000--0x1003 "BAM_P_CTRL0 (at 0xF9905000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST0"
        group.long 0x1004--0x1007 "BAM_P_RST0 (at 0xF9905004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT0"
        group.long 0x1008--0x100B "BAM_P_HALT0 (at 0xF9905008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG0"
        group.long 0x1030--0x1033 "BAM_P_TRUST_REG0 (at 0xF9905030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS0"
        group.long 0x1010--0x1013 "BAM_P_IRQ_STTS0 (at 0xF9905010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR0"
        group.long 0x1014--0x1017 "BAM_P_IRQ_CLR0 (at 0xF9905014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN0"
        group.long 0x1018--0x101B "BAM_P_IRQ_EN0 (at 0xF9905018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER0"
        group.long 0x101C--0x101F "BAM_P_TIMER0 (at 0xF990501C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL0"
        group.long 0x1020--0x1023 "BAM_P_TIMER_CTRL0 (at 0xF9905020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND0"
        group.long 0x1024--0x1027 "BAM_P_PRDCR_SDBND0 (at 0xF9905024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND0"
        group.long 0x1028--0x102B "BAM_P_CNSMR_SDBND0 (at 0xF9905028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR0"
        group.long 0x182C--0x182F "BAM_P_EVNT_DEST_ADDR0 (at 0xF990582C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG0"
        group.long 0x1818--0x181B "BAM_P_EVNT_REG0 (at 0xF9905818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS0"
        group.long 0x1800--0x1803 "BAM_P_SW_OFSTS0 (at 0xF9905800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR0"
        group.long 0x1824--0x1827 "BAM_P_DATA_FIFO_ADDR0 (at 0xF9905824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR0"
        group.long 0x181C--0x181F "BAM_P_DESC_FIFO_ADDR0 (at 0xF990581C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD0"
        group.long 0x1828--0x182B "BAM_P_EVNT_GEN_TRSHLD0 (at 0xF9905828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES0"
        group.long 0x1820--0x1823 "BAM_P_FIFO_SIZES0 (at 0xF9905820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_0"
        group.long 0x1834--0x1837 "BAM_P_RETR_CNTXT_0 (at 0xF9905834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_0"
        group.long 0x1838--0x183B "BAM_P_SI_CNTXT_0 (at 0xF9905838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_0"
        group.long 0x1830--0x1833 "BAM_P_DF_CNTXT_0 (at 0xF9905830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_0"
        group.long 0x1804--0x1807 "BAM_P_AU_PSM_CNTXT_1_0 (at 0xF9905804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_0"
        group.long 0x1808--0x180B "BAM_P_PSM_CNTXT_2_0 (at 0xF9905808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_0"
        group.long 0x180C--0x180F "BAM_P_PSM_CNTXT_3_0 (at 0xF990580C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_0"
        group.long 0x1810--0x1813 "BAM_P_PSM_CNTXT_4_0 (at 0xF9905810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_0"
        group.long 0x1814--0x1817 "BAM_P_PSM_CNTXT_5_0 (at 0xF9905814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 0
tree.end
tree "Pipe 1"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL1"
        group.long 0x2000--0x2003 "BAM_P_CTRL1 (at 0xF9906000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST1"
        group.long 0x2004--0x2007 "BAM_P_RST1 (at 0xF9906004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT1"
        group.long 0x2008--0x200B "BAM_P_HALT1 (at 0xF9906008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG1"
        group.long 0x2030--0x2033 "BAM_P_TRUST_REG1 (at 0xF9906030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS1"
        group.long 0x2010--0x2013 "BAM_P_IRQ_STTS1 (at 0xF9906010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR1"
        group.long 0x2014--0x2017 "BAM_P_IRQ_CLR1 (at 0xF9906014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN1"
        group.long 0x2018--0x201B "BAM_P_IRQ_EN1 (at 0xF9906018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER1"
        group.long 0x201C--0x201F "BAM_P_TIMER1 (at 0xF990601C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL1"
        group.long 0x2020--0x2023 "BAM_P_TIMER_CTRL1 (at 0xF9906020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND1"
        group.long 0x2024--0x2027 "BAM_P_PRDCR_SDBND1 (at 0xF9906024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND1"
        group.long 0x2028--0x202B "BAM_P_CNSMR_SDBND1 (at 0xF9906028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR1"
        group.long 0x282C--0x282F "BAM_P_EVNT_DEST_ADDR1 (at 0xF990682C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG1"
        group.long 0x2818--0x281B "BAM_P_EVNT_REG1 (at 0xF9906818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS1"
        group.long 0x2800--0x2803 "BAM_P_SW_OFSTS1 (at 0xF9906800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR1"
        group.long 0x2824--0x2827 "BAM_P_DATA_FIFO_ADDR1 (at 0xF9906824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR1"
        group.long 0x281C--0x281F "BAM_P_DESC_FIFO_ADDR1 (at 0xF990681C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD1"
        group.long 0x2828--0x282B "BAM_P_EVNT_GEN_TRSHLD1 (at 0xF9906828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES1"
        group.long 0x2820--0x2823 "BAM_P_FIFO_SIZES1 (at 0xF9906820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_1"
        group.long 0x2834--0x2837 "BAM_P_RETR_CNTXT_1 (at 0xF9906834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_1"
        group.long 0x2838--0x283B "BAM_P_SI_CNTXT_1 (at 0xF9906838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_1"
        group.long 0x2830--0x2833 "BAM_P_DF_CNTXT_1 (at 0xF9906830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_1"
        group.long 0x2804--0x2807 "BAM_P_AU_PSM_CNTXT_1_1 (at 0xF9906804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_1"
        group.long 0x2808--0x280B "BAM_P_PSM_CNTXT_2_1 (at 0xF9906808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_1"
        group.long 0x280C--0x280F "BAM_P_PSM_CNTXT_3_1 (at 0xF990680C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_1"
        group.long 0x2810--0x2813 "BAM_P_PSM_CNTXT_4_1 (at 0xF9906810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_1"
        group.long 0x2814--0x2817 "BAM_P_PSM_CNTXT_5_1 (at 0xF9906814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 1
tree.end
tree "Pipe 2"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL2"
        group.long 0x3000--0x3003 "BAM_P_CTRL2 (at 0xF9907000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST2"
        group.long 0x3004--0x3007 "BAM_P_RST2 (at 0xF9907004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT2"
        group.long 0x3008--0x300B "BAM_P_HALT2 (at 0xF9907008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG2"
        group.long 0x3030--0x3033 "BAM_P_TRUST_REG2 (at 0xF9907030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS2"
        group.long 0x3010--0x3013 "BAM_P_IRQ_STTS2 (at 0xF9907010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR2"
        group.long 0x3014--0x3017 "BAM_P_IRQ_CLR2 (at 0xF9907014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN2"
        group.long 0x3018--0x301B "BAM_P_IRQ_EN2 (at 0xF9907018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER2"
        group.long 0x301C--0x301F "BAM_P_TIMER2 (at 0xF990701C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL2"
        group.long 0x3020--0x3023 "BAM_P_TIMER_CTRL2 (at 0xF9907020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND2"
        group.long 0x3024--0x3027 "BAM_P_PRDCR_SDBND2 (at 0xF9907024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND2"
        group.long 0x3028--0x302B "BAM_P_CNSMR_SDBND2 (at 0xF9907028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR2"
        group.long 0x382C--0x382F "BAM_P_EVNT_DEST_ADDR2 (at 0xF990782C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG2"
        group.long 0x3818--0x381B "BAM_P_EVNT_REG2 (at 0xF9907818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS2"
        group.long 0x3800--0x3803 "BAM_P_SW_OFSTS2 (at 0xF9907800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR2"
        group.long 0x3824--0x3827 "BAM_P_DATA_FIFO_ADDR2 (at 0xF9907824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR2"
        group.long 0x381C--0x381F "BAM_P_DESC_FIFO_ADDR2 (at 0xF990781C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD2"
        group.long 0x3828--0x382B "BAM_P_EVNT_GEN_TRSHLD2 (at 0xF9907828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES2"
        group.long 0x3820--0x3823 "BAM_P_FIFO_SIZES2 (at 0xF9907820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_2"
        group.long 0x3834--0x3837 "BAM_P_RETR_CNTXT_2 (at 0xF9907834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_2"
        group.long 0x3838--0x383B "BAM_P_SI_CNTXT_2 (at 0xF9907838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_2"
        group.long 0x3830--0x3833 "BAM_P_DF_CNTXT_2 (at 0xF9907830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_2"
        group.long 0x3804--0x3807 "BAM_P_AU_PSM_CNTXT_1_2 (at 0xF9907804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_2"
        group.long 0x3808--0x380B "BAM_P_PSM_CNTXT_2_2 (at 0xF9907808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_2"
        group.long 0x380C--0x380F "BAM_P_PSM_CNTXT_3_2 (at 0xF990780C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_2"
        group.long 0x3810--0x3813 "BAM_P_PSM_CNTXT_4_2 (at 0xF9907810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_2"
        group.long 0x3814--0x3817 "BAM_P_PSM_CNTXT_5_2 (at 0xF9907814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 2
tree.end
tree "Pipe 3"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL3"
        group.long 0x4000--0x4003 "BAM_P_CTRL3 (at 0xF9908000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST3"
        group.long 0x4004--0x4007 "BAM_P_RST3 (at 0xF9908004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT3"
        group.long 0x4008--0x400B "BAM_P_HALT3 (at 0xF9908008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG3"
        group.long 0x4030--0x4033 "BAM_P_TRUST_REG3 (at 0xF9908030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS3"
        group.long 0x4010--0x4013 "BAM_P_IRQ_STTS3 (at 0xF9908010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR3"
        group.long 0x4014--0x4017 "BAM_P_IRQ_CLR3 (at 0xF9908014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN3"
        group.long 0x4018--0x401B "BAM_P_IRQ_EN3 (at 0xF9908018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER3"
        group.long 0x401C--0x401F "BAM_P_TIMER3 (at 0xF990801C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL3"
        group.long 0x4020--0x4023 "BAM_P_TIMER_CTRL3 (at 0xF9908020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND3"
        group.long 0x4024--0x4027 "BAM_P_PRDCR_SDBND3 (at 0xF9908024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND3"
        group.long 0x4028--0x402B "BAM_P_CNSMR_SDBND3 (at 0xF9908028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR3"
        group.long 0x482C--0x482F "BAM_P_EVNT_DEST_ADDR3 (at 0xF990882C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG3"
        group.long 0x4818--0x481B "BAM_P_EVNT_REG3 (at 0xF9908818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS3"
        group.long 0x4800--0x4803 "BAM_P_SW_OFSTS3 (at 0xF9908800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR3"
        group.long 0x4824--0x4827 "BAM_P_DATA_FIFO_ADDR3 (at 0xF9908824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR3"
        group.long 0x481C--0x481F "BAM_P_DESC_FIFO_ADDR3 (at 0xF990881C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD3"
        group.long 0x4828--0x482B "BAM_P_EVNT_GEN_TRSHLD3 (at 0xF9908828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES3"
        group.long 0x4820--0x4823 "BAM_P_FIFO_SIZES3 (at 0xF9908820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_3"
        group.long 0x4834--0x4837 "BAM_P_RETR_CNTXT_3 (at 0xF9908834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_3"
        group.long 0x4838--0x483B "BAM_P_SI_CNTXT_3 (at 0xF9908838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_3"
        group.long 0x4830--0x4833 "BAM_P_DF_CNTXT_3 (at 0xF9908830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_3"
        group.long 0x4804--0x4807 "BAM_P_AU_PSM_CNTXT_1_3 (at 0xF9908804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_3"
        group.long 0x4808--0x480B "BAM_P_PSM_CNTXT_2_3 (at 0xF9908808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_3"
        group.long 0x480C--0x480F "BAM_P_PSM_CNTXT_3_3 (at 0xF990880C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_3"
        group.long 0x4810--0x4813 "BAM_P_PSM_CNTXT_4_3 (at 0xF9908810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_3"
        group.long 0x4814--0x4817 "BAM_P_PSM_CNTXT_5_3 (at 0xF9908814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 3
tree.end
tree "Pipe 4"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL4"
        group.long 0x5000--0x5003 "BAM_P_CTRL4 (at 0xF9909000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST4"
        group.long 0x5004--0x5007 "BAM_P_RST4 (at 0xF9909004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT4"
        group.long 0x5008--0x500B "BAM_P_HALT4 (at 0xF9909008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG4"
        group.long 0x5030--0x5033 "BAM_P_TRUST_REG4 (at 0xF9909030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS4"
        group.long 0x5010--0x5013 "BAM_P_IRQ_STTS4 (at 0xF9909010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR4"
        group.long 0x5014--0x5017 "BAM_P_IRQ_CLR4 (at 0xF9909014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN4"
        group.long 0x5018--0x501B "BAM_P_IRQ_EN4 (at 0xF9909018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER4"
        group.long 0x501C--0x501F "BAM_P_TIMER4 (at 0xF990901C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL4"
        group.long 0x5020--0x5023 "BAM_P_TIMER_CTRL4 (at 0xF9909020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND4"
        group.long 0x5024--0x5027 "BAM_P_PRDCR_SDBND4 (at 0xF9909024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND4"
        group.long 0x5028--0x502B "BAM_P_CNSMR_SDBND4 (at 0xF9909028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR4"
        group.long 0x582C--0x582F "BAM_P_EVNT_DEST_ADDR4 (at 0xF990982C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG4"
        group.long 0x5818--0x581B "BAM_P_EVNT_REG4 (at 0xF9909818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS4"
        group.long 0x5800--0x5803 "BAM_P_SW_OFSTS4 (at 0xF9909800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR4"
        group.long 0x5824--0x5827 "BAM_P_DATA_FIFO_ADDR4 (at 0xF9909824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR4"
        group.long 0x581C--0x581F "BAM_P_DESC_FIFO_ADDR4 (at 0xF990981C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD4"
        group.long 0x5828--0x582B "BAM_P_EVNT_GEN_TRSHLD4 (at 0xF9909828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES4"
        group.long 0x5820--0x5823 "BAM_P_FIFO_SIZES4 (at 0xF9909820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_4"
        group.long 0x5834--0x5837 "BAM_P_RETR_CNTXT_4 (at 0xF9909834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_4"
        group.long 0x5838--0x583B "BAM_P_SI_CNTXT_4 (at 0xF9909838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_4"
        group.long 0x5830--0x5833 "BAM_P_DF_CNTXT_4 (at 0xF9909830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_4"
        group.long 0x5804--0x5807 "BAM_P_AU_PSM_CNTXT_1_4 (at 0xF9909804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_4"
        group.long 0x5808--0x580B "BAM_P_PSM_CNTXT_2_4 (at 0xF9909808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_4"
        group.long 0x580C--0x580F "BAM_P_PSM_CNTXT_3_4 (at 0xF990980C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_4"
        group.long 0x5810--0x5813 "BAM_P_PSM_CNTXT_4_4 (at 0xF9909810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_4"
        group.long 0x5814--0x5817 "BAM_P_PSM_CNTXT_5_4 (at 0xF9909814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 4
tree.end
tree "Pipe 5"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL5"
        group.long 0x6000--0x6003 "BAM_P_CTRL5 (at 0xF990A000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST5"
        group.long 0x6004--0x6007 "BAM_P_RST5 (at 0xF990A004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT5"
        group.long 0x6008--0x600B "BAM_P_HALT5 (at 0xF990A008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG5"
        group.long 0x6030--0x6033 "BAM_P_TRUST_REG5 (at 0xF990A030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS5"
        group.long 0x6010--0x6013 "BAM_P_IRQ_STTS5 (at 0xF990A010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR5"
        group.long 0x6014--0x6017 "BAM_P_IRQ_CLR5 (at 0xF990A014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN5"
        group.long 0x6018--0x601B "BAM_P_IRQ_EN5 (at 0xF990A018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER5"
        group.long 0x601C--0x601F "BAM_P_TIMER5 (at 0xF990A01C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL5"
        group.long 0x6020--0x6023 "BAM_P_TIMER_CTRL5 (at 0xF990A020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND5"
        group.long 0x6024--0x6027 "BAM_P_PRDCR_SDBND5 (at 0xF990A024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND5"
        group.long 0x6028--0x602B "BAM_P_CNSMR_SDBND5 (at 0xF990A028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR5"
        group.long 0x682C--0x682F "BAM_P_EVNT_DEST_ADDR5 (at 0xF990A82C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG5"
        group.long 0x6818--0x681B "BAM_P_EVNT_REG5 (at 0xF990A818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS5"
        group.long 0x6800--0x6803 "BAM_P_SW_OFSTS5 (at 0xF990A800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR5"
        group.long 0x6824--0x6827 "BAM_P_DATA_FIFO_ADDR5 (at 0xF990A824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR5"
        group.long 0x681C--0x681F "BAM_P_DESC_FIFO_ADDR5 (at 0xF990A81C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD5"
        group.long 0x6828--0x682B "BAM_P_EVNT_GEN_TRSHLD5 (at 0xF990A828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES5"
        group.long 0x6820--0x6823 "BAM_P_FIFO_SIZES5 (at 0xF990A820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_5"
        group.long 0x6834--0x6837 "BAM_P_RETR_CNTXT_5 (at 0xF990A834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_5"
        group.long 0x6838--0x683B "BAM_P_SI_CNTXT_5 (at 0xF990A838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_5"
        group.long 0x6830--0x6833 "BAM_P_DF_CNTXT_5 (at 0xF990A830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_5"
        group.long 0x6804--0x6807 "BAM_P_AU_PSM_CNTXT_1_5 (at 0xF990A804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_5"
        group.long 0x6808--0x680B "BAM_P_PSM_CNTXT_2_5 (at 0xF990A808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_5"
        group.long 0x680C--0x680F "BAM_P_PSM_CNTXT_3_5 (at 0xF990A80C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_5"
        group.long 0x6810--0x6813 "BAM_P_PSM_CNTXT_4_5 (at 0xF990A810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_5"
        group.long 0x6814--0x6817 "BAM_P_PSM_CNTXT_5_5 (at 0xF990A814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 5
tree.end
tree "Pipe 6"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL6"
        group.long 0x7000--0x7003 "BAM_P_CTRL6 (at 0xF990B000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST6"
        group.long 0x7004--0x7007 "BAM_P_RST6 (at 0xF990B004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT6"
        group.long 0x7008--0x700B "BAM_P_HALT6 (at 0xF990B008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG6"
        group.long 0x7030--0x7033 "BAM_P_TRUST_REG6 (at 0xF990B030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS6"
        group.long 0x7010--0x7013 "BAM_P_IRQ_STTS6 (at 0xF990B010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR6"
        group.long 0x7014--0x7017 "BAM_P_IRQ_CLR6 (at 0xF990B014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN6"
        group.long 0x7018--0x701B "BAM_P_IRQ_EN6 (at 0xF990B018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER6"
        group.long 0x701C--0x701F "BAM_P_TIMER6 (at 0xF990B01C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL6"
        group.long 0x7020--0x7023 "BAM_P_TIMER_CTRL6 (at 0xF990B020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND6"
        group.long 0x7024--0x7027 "BAM_P_PRDCR_SDBND6 (at 0xF990B024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND6"
        group.long 0x7028--0x702B "BAM_P_CNSMR_SDBND6 (at 0xF990B028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR6"
        group.long 0x782C--0x782F "BAM_P_EVNT_DEST_ADDR6 (at 0xF990B82C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG6"
        group.long 0x7818--0x781B "BAM_P_EVNT_REG6 (at 0xF990B818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS6"
        group.long 0x7800--0x7803 "BAM_P_SW_OFSTS6 (at 0xF990B800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR6"
        group.long 0x7824--0x7827 "BAM_P_DATA_FIFO_ADDR6 (at 0xF990B824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR6"
        group.long 0x781C--0x781F "BAM_P_DESC_FIFO_ADDR6 (at 0xF990B81C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD6"
        group.long 0x7828--0x782B "BAM_P_EVNT_GEN_TRSHLD6 (at 0xF990B828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES6"
        group.long 0x7820--0x7823 "BAM_P_FIFO_SIZES6 (at 0xF990B820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_6"
        group.long 0x7834--0x7837 "BAM_P_RETR_CNTXT_6 (at 0xF990B834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_6"
        group.long 0x7838--0x783B "BAM_P_SI_CNTXT_6 (at 0xF990B838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_6"
        group.long 0x7830--0x7833 "BAM_P_DF_CNTXT_6 (at 0xF990B830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_6"
        group.long 0x7804--0x7807 "BAM_P_AU_PSM_CNTXT_1_6 (at 0xF990B804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_6"
        group.long 0x7808--0x780B "BAM_P_PSM_CNTXT_2_6 (at 0xF990B808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_6"
        group.long 0x780C--0x780F "BAM_P_PSM_CNTXT_3_6 (at 0xF990B80C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_6"
        group.long 0x7810--0x7813 "BAM_P_PSM_CNTXT_4_6 (at 0xF990B810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_6"
        group.long 0x7814--0x7817 "BAM_P_PSM_CNTXT_5_6 (at 0xF990B814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 6
tree.end
tree "Pipe 7"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL7"
        group.long 0x8000--0x8003 "BAM_P_CTRL7 (at 0xF990C000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST7"
        group.long 0x8004--0x8007 "BAM_P_RST7 (at 0xF990C004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT7"
        group.long 0x8008--0x800B "BAM_P_HALT7 (at 0xF990C008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG7"
        group.long 0x8030--0x8033 "BAM_P_TRUST_REG7 (at 0xF990C030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS7"
        group.long 0x8010--0x8013 "BAM_P_IRQ_STTS7 (at 0xF990C010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR7"
        group.long 0x8014--0x8017 "BAM_P_IRQ_CLR7 (at 0xF990C014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN7"
        group.long 0x8018--0x801B "BAM_P_IRQ_EN7 (at 0xF990C018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER7"
        group.long 0x801C--0x801F "BAM_P_TIMER7 (at 0xF990C01C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL7"
        group.long 0x8020--0x8023 "BAM_P_TIMER_CTRL7 (at 0xF990C020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND7"
        group.long 0x8024--0x8027 "BAM_P_PRDCR_SDBND7 (at 0xF990C024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND7"
        group.long 0x8028--0x802B "BAM_P_CNSMR_SDBND7 (at 0xF990C028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR7"
        group.long 0x882C--0x882F "BAM_P_EVNT_DEST_ADDR7 (at 0xF990C82C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG7"
        group.long 0x8818--0x881B "BAM_P_EVNT_REG7 (at 0xF990C818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS7"
        group.long 0x8800--0x8803 "BAM_P_SW_OFSTS7 (at 0xF990C800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR7"
        group.long 0x8824--0x8827 "BAM_P_DATA_FIFO_ADDR7 (at 0xF990C824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR7"
        group.long 0x881C--0x881F "BAM_P_DESC_FIFO_ADDR7 (at 0xF990C81C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD7"
        group.long 0x8828--0x882B "BAM_P_EVNT_GEN_TRSHLD7 (at 0xF990C828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES7"
        group.long 0x8820--0x8823 "BAM_P_FIFO_SIZES7 (at 0xF990C820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_7"
        group.long 0x8834--0x8837 "BAM_P_RETR_CNTXT_7 (at 0xF990C834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_7"
        group.long 0x8838--0x883B "BAM_P_SI_CNTXT_7 (at 0xF990C838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_7"
        group.long 0x8830--0x8833 "BAM_P_DF_CNTXT_7 (at 0xF990C830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_7"
        group.long 0x8804--0x8807 "BAM_P_AU_PSM_CNTXT_1_7 (at 0xF990C804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_7"
        group.long 0x8808--0x880B "BAM_P_PSM_CNTXT_2_7 (at 0xF990C808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_7"
        group.long 0x880C--0x880F "BAM_P_PSM_CNTXT_3_7 (at 0xF990C80C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_7"
        group.long 0x8810--0x8813 "BAM_P_PSM_CNTXT_4_7 (at 0xF990C810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_7"
        group.long 0x8814--0x8817 "BAM_P_PSM_CNTXT_5_7 (at 0xF990C814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 7
tree.end
tree "Pipe 8"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL8"
        group.long 0x9000--0x9003 "BAM_P_CTRL8 (at 0xF990D000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST8"
        group.long 0x9004--0x9007 "BAM_P_RST8 (at 0xF990D004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT8"
        group.long 0x9008--0x900B "BAM_P_HALT8 (at 0xF990D008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG8"
        group.long 0x9030--0x9033 "BAM_P_TRUST_REG8 (at 0xF990D030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS8"
        group.long 0x9010--0x9013 "BAM_P_IRQ_STTS8 (at 0xF990D010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR8"
        group.long 0x9014--0x9017 "BAM_P_IRQ_CLR8 (at 0xF990D014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN8"
        group.long 0x9018--0x901B "BAM_P_IRQ_EN8 (at 0xF990D018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER8"
        group.long 0x901C--0x901F "BAM_P_TIMER8 (at 0xF990D01C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL8"
        group.long 0x9020--0x9023 "BAM_P_TIMER_CTRL8 (at 0xF990D020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND8"
        group.long 0x9024--0x9027 "BAM_P_PRDCR_SDBND8 (at 0xF990D024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND8"
        group.long 0x9028--0x902B "BAM_P_CNSMR_SDBND8 (at 0xF990D028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR8"
        group.long 0x982C--0x982F "BAM_P_EVNT_DEST_ADDR8 (at 0xF990D82C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG8"
        group.long 0x9818--0x981B "BAM_P_EVNT_REG8 (at 0xF990D818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS8"
        group.long 0x9800--0x9803 "BAM_P_SW_OFSTS8 (at 0xF990D800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR8"
        group.long 0x9824--0x9827 "BAM_P_DATA_FIFO_ADDR8 (at 0xF990D824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR8"
        group.long 0x981C--0x981F "BAM_P_DESC_FIFO_ADDR8 (at 0xF990D81C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD8"
        group.long 0x9828--0x982B "BAM_P_EVNT_GEN_TRSHLD8 (at 0xF990D828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES8"
        group.long 0x9820--0x9823 "BAM_P_FIFO_SIZES8 (at 0xF990D820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_8"
        group.long 0x9834--0x9837 "BAM_P_RETR_CNTXT_8 (at 0xF990D834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_8"
        group.long 0x9838--0x983B "BAM_P_SI_CNTXT_8 (at 0xF990D838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_8"
        group.long 0x9830--0x9833 "BAM_P_DF_CNTXT_8 (at 0xF990D830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_8"
        group.long 0x9804--0x9807 "BAM_P_AU_PSM_CNTXT_1_8 (at 0xF990D804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_8"
        group.long 0x9808--0x980B "BAM_P_PSM_CNTXT_2_8 (at 0xF990D808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_8"
        group.long 0x980C--0x980F "BAM_P_PSM_CNTXT_3_8 (at 0xF990D80C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_8"
        group.long 0x9810--0x9813 "BAM_P_PSM_CNTXT_4_8 (at 0xF990D810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_8"
        group.long 0x9814--0x9817 "BAM_P_PSM_CNTXT_5_8 (at 0xF990D814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 8
tree.end
tree "Pipe 9"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL9"
        group.long 0xA000--0xA003 "BAM_P_CTRL9 (at 0xF990E000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST9"
        group.long 0xA004--0xA007 "BAM_P_RST9 (at 0xF990E004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT9"
        group.long 0xA008--0xA00B "BAM_P_HALT9 (at 0xF990E008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG9"
        group.long 0xA030--0xA033 "BAM_P_TRUST_REG9 (at 0xF990E030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS9"
        group.long 0xA010--0xA013 "BAM_P_IRQ_STTS9 (at 0xF990E010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR9"
        group.long 0xA014--0xA017 "BAM_P_IRQ_CLR9 (at 0xF990E014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN9"
        group.long 0xA018--0xA01B "BAM_P_IRQ_EN9 (at 0xF990E018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER9"
        group.long 0xA01C--0xA01F "BAM_P_TIMER9 (at 0xF990E01C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL9"
        group.long 0xA020--0xA023 "BAM_P_TIMER_CTRL9 (at 0xF990E020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND9"
        group.long 0xA024--0xA027 "BAM_P_PRDCR_SDBND9 (at 0xF990E024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND9"
        group.long 0xA028--0xA02B "BAM_P_CNSMR_SDBND9 (at 0xF990E028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR9"
        group.long 0xA82C--0xA82F "BAM_P_EVNT_DEST_ADDR9 (at 0xF990E82C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG9"
        group.long 0xA818--0xA81B "BAM_P_EVNT_REG9 (at 0xF990E818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS9"
        group.long 0xA800--0xA803 "BAM_P_SW_OFSTS9 (at 0xF990E800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR9"
        group.long 0xA824--0xA827 "BAM_P_DATA_FIFO_ADDR9 (at 0xF990E824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR9"
        group.long 0xA81C--0xA81F "BAM_P_DESC_FIFO_ADDR9 (at 0xF990E81C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD9"
        group.long 0xA828--0xA82B "BAM_P_EVNT_GEN_TRSHLD9 (at 0xF990E828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES9"
        group.long 0xA820--0xA823 "BAM_P_FIFO_SIZES9 (at 0xF990E820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_9"
        group.long 0xA834--0xA837 "BAM_P_RETR_CNTXT_9 (at 0xF990E834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_9"
        group.long 0xA838--0xA83B "BAM_P_SI_CNTXT_9 (at 0xF990E838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_9"
        group.long 0xA830--0xA833 "BAM_P_DF_CNTXT_9 (at 0xF990E830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_9"
        group.long 0xA804--0xA807 "BAM_P_AU_PSM_CNTXT_1_9 (at 0xF990E804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_9"
        group.long 0xA808--0xA80B "BAM_P_PSM_CNTXT_2_9 (at 0xF990E808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_9"
        group.long 0xA80C--0xA80F "BAM_P_PSM_CNTXT_3_9 (at 0xF990E80C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_9"
        group.long 0xA810--0xA813 "BAM_P_PSM_CNTXT_4_9 (at 0xF990E810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_9"
        group.long 0xA814--0xA817 "BAM_P_PSM_CNTXT_5_9 (at 0xF990E814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 9
tree.end
tree "Pipe 10"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL10"
        group.long 0xB000--0xB003 "BAM_P_CTRL10 (at 0xF990F000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST10"
        group.long 0xB004--0xB007 "BAM_P_RST10 (at 0xF990F004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT10"
        group.long 0xB008--0xB00B "BAM_P_HALT10 (at 0xF990F008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG10"
        group.long 0xB030--0xB033 "BAM_P_TRUST_REG10 (at 0xF990F030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS10"
        group.long 0xB010--0xB013 "BAM_P_IRQ_STTS10 (at 0xF990F010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR10"
        group.long 0xB014--0xB017 "BAM_P_IRQ_CLR10 (at 0xF990F014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN10"
        group.long 0xB018--0xB01B "BAM_P_IRQ_EN10 (at 0xF990F018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER10"
        group.long 0xB01C--0xB01F "BAM_P_TIMER10 (at 0xF990F01C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL10"
        group.long 0xB020--0xB023 "BAM_P_TIMER_CTRL10 (at 0xF990F020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND10"
        group.long 0xB024--0xB027 "BAM_P_PRDCR_SDBND10 (at 0xF990F024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND10"
        group.long 0xB028--0xB02B "BAM_P_CNSMR_SDBND10 (at 0xF990F028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR10"
        group.long 0xB82C--0xB82F "BAM_P_EVNT_DEST_ADDR10 (at 0xF990F82C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG10"
        group.long 0xB818--0xB81B "BAM_P_EVNT_REG10 (at 0xF990F818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS10"
        group.long 0xB800--0xB803 "BAM_P_SW_OFSTS10 (at 0xF990F800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR10"
        group.long 0xB824--0xB827 "BAM_P_DATA_FIFO_ADDR10 (at 0xF990F824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR10"
        group.long 0xB81C--0xB81F "BAM_P_DESC_FIFO_ADDR10 (at 0xF990F81C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD10"
        group.long 0xB828--0xB82B "BAM_P_EVNT_GEN_TRSHLD10 (at 0xF990F828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES10"
        group.long 0xB820--0xB823 "BAM_P_FIFO_SIZES10 (at 0xF990F820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_10"
        group.long 0xB834--0xB837 "BAM_P_RETR_CNTXT_10 (at 0xF990F834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_10"
        group.long 0xB838--0xB83B "BAM_P_SI_CNTXT_10 (at 0xF990F838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_10"
        group.long 0xB830--0xB833 "BAM_P_DF_CNTXT_10 (at 0xF990F830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_10"
        group.long 0xB804--0xB807 "BAM_P_AU_PSM_CNTXT_1_10 (at 0xF990F804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_10"
        group.long 0xB808--0xB80B "BAM_P_PSM_CNTXT_2_10 (at 0xF990F808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_10"
        group.long 0xB80C--0xB80F "BAM_P_PSM_CNTXT_3_10 (at 0xF990F80C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_10"
        group.long 0xB810--0xB813 "BAM_P_PSM_CNTXT_4_10 (at 0xF990F810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_10"
        group.long 0xB814--0xB817 "BAM_P_PSM_CNTXT_5_10 (at 0xF990F814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 10
tree.end
tree "Pipe 11"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL11"
        group.long 0xC000--0xC003 "BAM_P_CTRL11 (at 0xF9910000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST11"
        group.long 0xC004--0xC007 "BAM_P_RST11 (at 0xF9910004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT11"
        group.long 0xC008--0xC00B "BAM_P_HALT11 (at 0xF9910008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG11"
        group.long 0xC030--0xC033 "BAM_P_TRUST_REG11 (at 0xF9910030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS11"
        group.long 0xC010--0xC013 "BAM_P_IRQ_STTS11 (at 0xF9910010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR11"
        group.long 0xC014--0xC017 "BAM_P_IRQ_CLR11 (at 0xF9910014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN11"
        group.long 0xC018--0xC01B "BAM_P_IRQ_EN11 (at 0xF9910018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER11"
        group.long 0xC01C--0xC01F "BAM_P_TIMER11 (at 0xF991001C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL11"
        group.long 0xC020--0xC023 "BAM_P_TIMER_CTRL11 (at 0xF9910020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND11"
        group.long 0xC024--0xC027 "BAM_P_PRDCR_SDBND11 (at 0xF9910024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND11"
        group.long 0xC028--0xC02B "BAM_P_CNSMR_SDBND11 (at 0xF9910028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR11"
        group.long 0xC82C--0xC82F "BAM_P_EVNT_DEST_ADDR11 (at 0xF991082C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG11"
        group.long 0xC818--0xC81B "BAM_P_EVNT_REG11 (at 0xF9910818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS11"
        group.long 0xC800--0xC803 "BAM_P_SW_OFSTS11 (at 0xF9910800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR11"
        group.long 0xC824--0xC827 "BAM_P_DATA_FIFO_ADDR11 (at 0xF9910824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR11"
        group.long 0xC81C--0xC81F "BAM_P_DESC_FIFO_ADDR11 (at 0xF991081C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD11"
        group.long 0xC828--0xC82B "BAM_P_EVNT_GEN_TRSHLD11 (at 0xF9910828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES11"
        group.long 0xC820--0xC823 "BAM_P_FIFO_SIZES11 (at 0xF9910820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_11"
        group.long 0xC834--0xC837 "BAM_P_RETR_CNTXT_11 (at 0xF9910834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_11"
        group.long 0xC838--0xC83B "BAM_P_SI_CNTXT_11 (at 0xF9910838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_11"
        group.long 0xC830--0xC833 "BAM_P_DF_CNTXT_11 (at 0xF9910830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_11"
        group.long 0xC804--0xC807 "BAM_P_AU_PSM_CNTXT_1_11 (at 0xF9910804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_11"
        group.long 0xC808--0xC80B "BAM_P_PSM_CNTXT_2_11 (at 0xF9910808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_11"
        group.long 0xC80C--0xC80F "BAM_P_PSM_CNTXT_3_11 (at 0xF991080C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_11"
        group.long 0xC810--0xC813 "BAM_P_PSM_CNTXT_4_11 (at 0xF9910810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_11"
        group.long 0xC814--0xC817 "BAM_P_PSM_CNTXT_5_11 (at 0xF9910814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 11
tree.end
tree "Pipe 12"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL12"
        group.long 0xD000--0xD003 "BAM_P_CTRL12 (at 0xF9911000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST12"
        group.long 0xD004--0xD007 "BAM_P_RST12 (at 0xF9911004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT12"
        group.long 0xD008--0xD00B "BAM_P_HALT12 (at 0xF9911008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG12"
        group.long 0xD030--0xD033 "BAM_P_TRUST_REG12 (at 0xF9911030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS12"
        group.long 0xD010--0xD013 "BAM_P_IRQ_STTS12 (at 0xF9911010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR12"
        group.long 0xD014--0xD017 "BAM_P_IRQ_CLR12 (at 0xF9911014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN12"
        group.long 0xD018--0xD01B "BAM_P_IRQ_EN12 (at 0xF9911018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER12"
        group.long 0xD01C--0xD01F "BAM_P_TIMER12 (at 0xF991101C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL12"
        group.long 0xD020--0xD023 "BAM_P_TIMER_CTRL12 (at 0xF9911020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND12"
        group.long 0xD024--0xD027 "BAM_P_PRDCR_SDBND12 (at 0xF9911024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND12"
        group.long 0xD028--0xD02B "BAM_P_CNSMR_SDBND12 (at 0xF9911028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR12"
        group.long 0xD82C--0xD82F "BAM_P_EVNT_DEST_ADDR12 (at 0xF991182C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG12"
        group.long 0xD818--0xD81B "BAM_P_EVNT_REG12 (at 0xF9911818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS12"
        group.long 0xD800--0xD803 "BAM_P_SW_OFSTS12 (at 0xF9911800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR12"
        group.long 0xD824--0xD827 "BAM_P_DATA_FIFO_ADDR12 (at 0xF9911824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR12"
        group.long 0xD81C--0xD81F "BAM_P_DESC_FIFO_ADDR12 (at 0xF991181C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD12"
        group.long 0xD828--0xD82B "BAM_P_EVNT_GEN_TRSHLD12 (at 0xF9911828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES12"
        group.long 0xD820--0xD823 "BAM_P_FIFO_SIZES12 (at 0xF9911820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_12"
        group.long 0xD834--0xD837 "BAM_P_RETR_CNTXT_12 (at 0xF9911834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_12"
        group.long 0xD838--0xD83B "BAM_P_SI_CNTXT_12 (at 0xF9911838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_12"
        group.long 0xD830--0xD833 "BAM_P_DF_CNTXT_12 (at 0xF9911830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_12"
        group.long 0xD804--0xD807 "BAM_P_AU_PSM_CNTXT_1_12 (at 0xF9911804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_12"
        group.long 0xD808--0xD80B "BAM_P_PSM_CNTXT_2_12 (at 0xF9911808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_12"
        group.long 0xD80C--0xD80F "BAM_P_PSM_CNTXT_3_12 (at 0xF991180C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_12"
        group.long 0xD810--0xD813 "BAM_P_PSM_CNTXT_4_12 (at 0xF9911810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_12"
        group.long 0xD814--0xD817 "BAM_P_PSM_CNTXT_5_12 (at 0xF9911814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 12
tree.end
tree "Pipe 13"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL13"
        group.long 0xE000--0xE003 "BAM_P_CTRL13 (at 0xF9912000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST13"
        group.long 0xE004--0xE007 "BAM_P_RST13 (at 0xF9912004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT13"
        group.long 0xE008--0xE00B "BAM_P_HALT13 (at 0xF9912008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG13"
        group.long 0xE030--0xE033 "BAM_P_TRUST_REG13 (at 0xF9912030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS13"
        group.long 0xE010--0xE013 "BAM_P_IRQ_STTS13 (at 0xF9912010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR13"
        group.long 0xE014--0xE017 "BAM_P_IRQ_CLR13 (at 0xF9912014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN13"
        group.long 0xE018--0xE01B "BAM_P_IRQ_EN13 (at 0xF9912018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER13"
        group.long 0xE01C--0xE01F "BAM_P_TIMER13 (at 0xF991201C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL13"
        group.long 0xE020--0xE023 "BAM_P_TIMER_CTRL13 (at 0xF9912020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND13"
        group.long 0xE024--0xE027 "BAM_P_PRDCR_SDBND13 (at 0xF9912024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND13"
        group.long 0xE028--0xE02B "BAM_P_CNSMR_SDBND13 (at 0xF9912028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR13"
        group.long 0xE82C--0xE82F "BAM_P_EVNT_DEST_ADDR13 (at 0xF991282C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG13"
        group.long 0xE818--0xE81B "BAM_P_EVNT_REG13 (at 0xF9912818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS13"
        group.long 0xE800--0xE803 "BAM_P_SW_OFSTS13 (at 0xF9912800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR13"
        group.long 0xE824--0xE827 "BAM_P_DATA_FIFO_ADDR13 (at 0xF9912824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR13"
        group.long 0xE81C--0xE81F "BAM_P_DESC_FIFO_ADDR13 (at 0xF991281C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD13"
        group.long 0xE828--0xE82B "BAM_P_EVNT_GEN_TRSHLD13 (at 0xF9912828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES13"
        group.long 0xE820--0xE823 "BAM_P_FIFO_SIZES13 (at 0xF9912820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_13"
        group.long 0xE834--0xE837 "BAM_P_RETR_CNTXT_13 (at 0xF9912834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_13"
        group.long 0xE838--0xE83B "BAM_P_SI_CNTXT_13 (at 0xF9912838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_13"
        group.long 0xE830--0xE833 "BAM_P_DF_CNTXT_13 (at 0xF9912830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_13"
        group.long 0xE804--0xE807 "BAM_P_AU_PSM_CNTXT_1_13 (at 0xF9912804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_13"
        group.long 0xE808--0xE80B "BAM_P_PSM_CNTXT_2_13 (at 0xF9912808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_13"
        group.long 0xE80C--0xE80F "BAM_P_PSM_CNTXT_3_13 (at 0xF991280C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_13"
        group.long 0xE810--0xE813 "BAM_P_PSM_CNTXT_4_13 (at 0xF9912810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_13"
        group.long 0xE814--0xE817 "BAM_P_PSM_CNTXT_5_13 (at 0xF9912814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 13
tree.end
tree "Pipe 14"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL14"
        group.long 0xF000--0xF003 "BAM_P_CTRL14 (at 0xF9913000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST14"
        group.long 0xF004--0xF007 "BAM_P_RST14 (at 0xF9913004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT14"
        group.long 0xF008--0xF00B "BAM_P_HALT14 (at 0xF9913008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG14"
        group.long 0xF030--0xF033 "BAM_P_TRUST_REG14 (at 0xF9913030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS14"
        group.long 0xF010--0xF013 "BAM_P_IRQ_STTS14 (at 0xF9913010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR14"
        group.long 0xF014--0xF017 "BAM_P_IRQ_CLR14 (at 0xF9913014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN14"
        group.long 0xF018--0xF01B "BAM_P_IRQ_EN14 (at 0xF9913018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER14"
        group.long 0xF01C--0xF01F "BAM_P_TIMER14 (at 0xF991301C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL14"
        group.long 0xF020--0xF023 "BAM_P_TIMER_CTRL14 (at 0xF9913020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND14"
        group.long 0xF024--0xF027 "BAM_P_PRDCR_SDBND14 (at 0xF9913024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND14"
        group.long 0xF028--0xF02B "BAM_P_CNSMR_SDBND14 (at 0xF9913028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR14"
        group.long 0xF82C--0xF82F "BAM_P_EVNT_DEST_ADDR14 (at 0xF991382C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG14"
        group.long 0xF818--0xF81B "BAM_P_EVNT_REG14 (at 0xF9913818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS14"
        group.long 0xF800--0xF803 "BAM_P_SW_OFSTS14 (at 0xF9913800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR14"
        group.long 0xF824--0xF827 "BAM_P_DATA_FIFO_ADDR14 (at 0xF9913824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR14"
        group.long 0xF81C--0xF81F "BAM_P_DESC_FIFO_ADDR14 (at 0xF991381C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD14"
        group.long 0xF828--0xF82B "BAM_P_EVNT_GEN_TRSHLD14 (at 0xF9913828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES14"
        group.long 0xF820--0xF823 "BAM_P_FIFO_SIZES14 (at 0xF9913820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_14"
        group.long 0xF834--0xF837 "BAM_P_RETR_CNTXT_14 (at 0xF9913834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_14"
        group.long 0xF838--0xF83B "BAM_P_SI_CNTXT_14 (at 0xF9913838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_14"
        group.long 0xF830--0xF833 "BAM_P_DF_CNTXT_14 (at 0xF9913830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_14"
        group.long 0xF804--0xF807 "BAM_P_AU_PSM_CNTXT_1_14 (at 0xF9913804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_14"
        group.long 0xF808--0xF80B "BAM_P_PSM_CNTXT_2_14 (at 0xF9913808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_14"
        group.long 0xF80C--0xF80F "BAM_P_PSM_CNTXT_3_14 (at 0xF991380C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_14"
        group.long 0xF810--0xF813 "BAM_P_PSM_CNTXT_4_14 (at 0xF9913810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_14"
        group.long 0xF814--0xF817 "BAM_P_PSM_CNTXT_5_14 (at 0xF9913814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 14
tree.end
tree "Pipe 15"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL15"
        group.long 0x10000--0x10003 "BAM_P_CTRL15 (at 0xF9914000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST15"
        group.long 0x10004--0x10007 "BAM_P_RST15 (at 0xF9914004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT15"
        group.long 0x10008--0x1000B "BAM_P_HALT15 (at 0xF9914008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG15"
        group.long 0x10030--0x10033 "BAM_P_TRUST_REG15 (at 0xF9914030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS15"
        group.long 0x10010--0x10013 "BAM_P_IRQ_STTS15 (at 0xF9914010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR15"
        group.long 0x10014--0x10017 "BAM_P_IRQ_CLR15 (at 0xF9914014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN15"
        group.long 0x10018--0x1001B "BAM_P_IRQ_EN15 (at 0xF9914018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER15"
        group.long 0x1001C--0x1001F "BAM_P_TIMER15 (at 0xF991401C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL15"
        group.long 0x10020--0x10023 "BAM_P_TIMER_CTRL15 (at 0xF9914020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND15"
        group.long 0x10024--0x10027 "BAM_P_PRDCR_SDBND15 (at 0xF9914024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND15"
        group.long 0x10028--0x1002B "BAM_P_CNSMR_SDBND15 (at 0xF9914028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR15"
        group.long 0x1082C--0x1082F "BAM_P_EVNT_DEST_ADDR15 (at 0xF991482C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG15"
        group.long 0x10818--0x1081B "BAM_P_EVNT_REG15 (at 0xF9914818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS15"
        group.long 0x10800--0x10803 "BAM_P_SW_OFSTS15 (at 0xF9914800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR15"
        group.long 0x10824--0x10827 "BAM_P_DATA_FIFO_ADDR15 (at 0xF9914824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR15"
        group.long 0x1081C--0x1081F "BAM_P_DESC_FIFO_ADDR15 (at 0xF991481C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD15"
        group.long 0x10828--0x1082B "BAM_P_EVNT_GEN_TRSHLD15 (at 0xF9914828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES15"
        group.long 0x10820--0x10823 "BAM_P_FIFO_SIZES15 (at 0xF9914820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_15"
        group.long 0x10834--0x10837 "BAM_P_RETR_CNTXT_15 (at 0xF9914834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_15"
        group.long 0x10838--0x1083B "BAM_P_SI_CNTXT_15 (at 0xF9914838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_15"
        group.long 0x10830--0x10833 "BAM_P_DF_CNTXT_15 (at 0xF9914830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_15"
        group.long 0x10804--0x10807 "BAM_P_AU_PSM_CNTXT_1_15 (at 0xF9914804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_15"
        group.long 0x10808--0x1080B "BAM_P_PSM_CNTXT_2_15 (at 0xF9914808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_15"
        group.long 0x1080C--0x1080F "BAM_P_PSM_CNTXT_3_15 (at 0xF991480C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_15"
        group.long 0x10810--0x10813 "BAM_P_PSM_CNTXT_4_15 (at 0xF9914810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_15"
        group.long 0x10814--0x10817 "BAM_P_PSM_CNTXT_5_15 (at 0xF9914814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 15
tree.end
tree "Pipe 16"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL16"
        group.long 0x11000--0x11003 "BAM_P_CTRL16 (at 0xF9915000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST16"
        group.long 0x11004--0x11007 "BAM_P_RST16 (at 0xF9915004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT16"
        group.long 0x11008--0x1100B "BAM_P_HALT16 (at 0xF9915008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG16"
        group.long 0x11030--0x11033 "BAM_P_TRUST_REG16 (at 0xF9915030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS16"
        group.long 0x11010--0x11013 "BAM_P_IRQ_STTS16 (at 0xF9915010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR16"
        group.long 0x11014--0x11017 "BAM_P_IRQ_CLR16 (at 0xF9915014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN16"
        group.long 0x11018--0x1101B "BAM_P_IRQ_EN16 (at 0xF9915018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER16"
        group.long 0x1101C--0x1101F "BAM_P_TIMER16 (at 0xF991501C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL16"
        group.long 0x11020--0x11023 "BAM_P_TIMER_CTRL16 (at 0xF9915020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND16"
        group.long 0x11024--0x11027 "BAM_P_PRDCR_SDBND16 (at 0xF9915024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND16"
        group.long 0x11028--0x1102B "BAM_P_CNSMR_SDBND16 (at 0xF9915028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR16"
        group.long 0x1182C--0x1182F "BAM_P_EVNT_DEST_ADDR16 (at 0xF991582C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG16"
        group.long 0x11818--0x1181B "BAM_P_EVNT_REG16 (at 0xF9915818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS16"
        group.long 0x11800--0x11803 "BAM_P_SW_OFSTS16 (at 0xF9915800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR16"
        group.long 0x11824--0x11827 "BAM_P_DATA_FIFO_ADDR16 (at 0xF9915824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR16"
        group.long 0x1181C--0x1181F "BAM_P_DESC_FIFO_ADDR16 (at 0xF991581C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD16"
        group.long 0x11828--0x1182B "BAM_P_EVNT_GEN_TRSHLD16 (at 0xF9915828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES16"
        group.long 0x11820--0x11823 "BAM_P_FIFO_SIZES16 (at 0xF9915820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_16"
        group.long 0x11834--0x11837 "BAM_P_RETR_CNTXT_16 (at 0xF9915834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_16"
        group.long 0x11838--0x1183B "BAM_P_SI_CNTXT_16 (at 0xF9915838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_16"
        group.long 0x11830--0x11833 "BAM_P_DF_CNTXT_16 (at 0xF9915830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_16"
        group.long 0x11804--0x11807 "BAM_P_AU_PSM_CNTXT_1_16 (at 0xF9915804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_16"
        group.long 0x11808--0x1180B "BAM_P_PSM_CNTXT_2_16 (at 0xF9915808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_16"
        group.long 0x1180C--0x1180F "BAM_P_PSM_CNTXT_3_16 (at 0xF991580C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_16"
        group.long 0x11810--0x11813 "BAM_P_PSM_CNTXT_4_16 (at 0xF9915810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_16"
        group.long 0x11814--0x11817 "BAM_P_PSM_CNTXT_5_16 (at 0xF9915814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 16
tree.end
tree "Pipe 17"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL17"
        group.long 0x12000--0x12003 "BAM_P_CTRL17 (at 0xF9916000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST17"
        group.long 0x12004--0x12007 "BAM_P_RST17 (at 0xF9916004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT17"
        group.long 0x12008--0x1200B "BAM_P_HALT17 (at 0xF9916008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG17"
        group.long 0x12030--0x12033 "BAM_P_TRUST_REG17 (at 0xF9916030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS17"
        group.long 0x12010--0x12013 "BAM_P_IRQ_STTS17 (at 0xF9916010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR17"
        group.long 0x12014--0x12017 "BAM_P_IRQ_CLR17 (at 0xF9916014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN17"
        group.long 0x12018--0x1201B "BAM_P_IRQ_EN17 (at 0xF9916018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER17"
        group.long 0x1201C--0x1201F "BAM_P_TIMER17 (at 0xF991601C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL17"
        group.long 0x12020--0x12023 "BAM_P_TIMER_CTRL17 (at 0xF9916020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND17"
        group.long 0x12024--0x12027 "BAM_P_PRDCR_SDBND17 (at 0xF9916024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND17"
        group.long 0x12028--0x1202B "BAM_P_CNSMR_SDBND17 (at 0xF9916028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR17"
        group.long 0x1282C--0x1282F "BAM_P_EVNT_DEST_ADDR17 (at 0xF991682C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG17"
        group.long 0x12818--0x1281B "BAM_P_EVNT_REG17 (at 0xF9916818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS17"
        group.long 0x12800--0x12803 "BAM_P_SW_OFSTS17 (at 0xF9916800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR17"
        group.long 0x12824--0x12827 "BAM_P_DATA_FIFO_ADDR17 (at 0xF9916824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR17"
        group.long 0x1281C--0x1281F "BAM_P_DESC_FIFO_ADDR17 (at 0xF991681C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD17"
        group.long 0x12828--0x1282B "BAM_P_EVNT_GEN_TRSHLD17 (at 0xF9916828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES17"
        group.long 0x12820--0x12823 "BAM_P_FIFO_SIZES17 (at 0xF9916820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_17"
        group.long 0x12834--0x12837 "BAM_P_RETR_CNTXT_17 (at 0xF9916834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_17"
        group.long 0x12838--0x1283B "BAM_P_SI_CNTXT_17 (at 0xF9916838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_17"
        group.long 0x12830--0x12833 "BAM_P_DF_CNTXT_17 (at 0xF9916830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_17"
        group.long 0x12804--0x12807 "BAM_P_AU_PSM_CNTXT_1_17 (at 0xF9916804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_17"
        group.long 0x12808--0x1280B "BAM_P_PSM_CNTXT_2_17 (at 0xF9916808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_17"
        group.long 0x1280C--0x1280F "BAM_P_PSM_CNTXT_3_17 (at 0xF991680C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_17"
        group.long 0x12810--0x12813 "BAM_P_PSM_CNTXT_4_17 (at 0xF9916810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_17"
        group.long 0x12814--0x12817 "BAM_P_PSM_CNTXT_5_17 (at 0xF9916814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 17
tree.end
tree "Pipe 18"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL18"
        group.long 0x13000--0x13003 "BAM_P_CTRL18 (at 0xF9917000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST18"
        group.long 0x13004--0x13007 "BAM_P_RST18 (at 0xF9917004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT18"
        group.long 0x13008--0x1300B "BAM_P_HALT18 (at 0xF9917008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG18"
        group.long 0x13030--0x13033 "BAM_P_TRUST_REG18 (at 0xF9917030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS18"
        group.long 0x13010--0x13013 "BAM_P_IRQ_STTS18 (at 0xF9917010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR18"
        group.long 0x13014--0x13017 "BAM_P_IRQ_CLR18 (at 0xF9917014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN18"
        group.long 0x13018--0x1301B "BAM_P_IRQ_EN18 (at 0xF9917018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER18"
        group.long 0x1301C--0x1301F "BAM_P_TIMER18 (at 0xF991701C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL18"
        group.long 0x13020--0x13023 "BAM_P_TIMER_CTRL18 (at 0xF9917020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND18"
        group.long 0x13024--0x13027 "BAM_P_PRDCR_SDBND18 (at 0xF9917024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND18"
        group.long 0x13028--0x1302B "BAM_P_CNSMR_SDBND18 (at 0xF9917028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR18"
        group.long 0x1382C--0x1382F "BAM_P_EVNT_DEST_ADDR18 (at 0xF991782C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG18"
        group.long 0x13818--0x1381B "BAM_P_EVNT_REG18 (at 0xF9917818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS18"
        group.long 0x13800--0x13803 "BAM_P_SW_OFSTS18 (at 0xF9917800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR18"
        group.long 0x13824--0x13827 "BAM_P_DATA_FIFO_ADDR18 (at 0xF9917824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR18"
        group.long 0x1381C--0x1381F "BAM_P_DESC_FIFO_ADDR18 (at 0xF991781C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD18"
        group.long 0x13828--0x1382B "BAM_P_EVNT_GEN_TRSHLD18 (at 0xF9917828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES18"
        group.long 0x13820--0x13823 "BAM_P_FIFO_SIZES18 (at 0xF9917820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_18"
        group.long 0x13834--0x13837 "BAM_P_RETR_CNTXT_18 (at 0xF9917834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_18"
        group.long 0x13838--0x1383B "BAM_P_SI_CNTXT_18 (at 0xF9917838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_18"
        group.long 0x13830--0x13833 "BAM_P_DF_CNTXT_18 (at 0xF9917830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_18"
        group.long 0x13804--0x13807 "BAM_P_AU_PSM_CNTXT_1_18 (at 0xF9917804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_18"
        group.long 0x13808--0x1380B "BAM_P_PSM_CNTXT_2_18 (at 0xF9917808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_18"
        group.long 0x1380C--0x1380F "BAM_P_PSM_CNTXT_3_18 (at 0xF991780C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_18"
        group.long 0x13810--0x13813 "BAM_P_PSM_CNTXT_4_18 (at 0xF9917810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_18"
        group.long 0x13814--0x13817 "BAM_P_PSM_CNTXT_5_18 (at 0xF9917814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 18
tree.end
tree "Pipe 19"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL19"
        group.long 0x14000--0x14003 "BAM_P_CTRL19 (at 0xF9918000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST19"
        group.long 0x14004--0x14007 "BAM_P_RST19 (at 0xF9918004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT19"
        group.long 0x14008--0x1400B "BAM_P_HALT19 (at 0xF9918008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG19"
        group.long 0x14030--0x14033 "BAM_P_TRUST_REG19 (at 0xF9918030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS19"
        group.long 0x14010--0x14013 "BAM_P_IRQ_STTS19 (at 0xF9918010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR19"
        group.long 0x14014--0x14017 "BAM_P_IRQ_CLR19 (at 0xF9918014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN19"
        group.long 0x14018--0x1401B "BAM_P_IRQ_EN19 (at 0xF9918018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER19"
        group.long 0x1401C--0x1401F "BAM_P_TIMER19 (at 0xF991801C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL19"
        group.long 0x14020--0x14023 "BAM_P_TIMER_CTRL19 (at 0xF9918020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND19"
        group.long 0x14024--0x14027 "BAM_P_PRDCR_SDBND19 (at 0xF9918024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND19"
        group.long 0x14028--0x1402B "BAM_P_CNSMR_SDBND19 (at 0xF9918028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR19"
        group.long 0x1482C--0x1482F "BAM_P_EVNT_DEST_ADDR19 (at 0xF991882C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG19"
        group.long 0x14818--0x1481B "BAM_P_EVNT_REG19 (at 0xF9918818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS19"
        group.long 0x14800--0x14803 "BAM_P_SW_OFSTS19 (at 0xF9918800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR19"
        group.long 0x14824--0x14827 "BAM_P_DATA_FIFO_ADDR19 (at 0xF9918824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR19"
        group.long 0x1481C--0x1481F "BAM_P_DESC_FIFO_ADDR19 (at 0xF991881C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD19"
        group.long 0x14828--0x1482B "BAM_P_EVNT_GEN_TRSHLD19 (at 0xF9918828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES19"
        group.long 0x14820--0x14823 "BAM_P_FIFO_SIZES19 (at 0xF9918820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_19"
        group.long 0x14834--0x14837 "BAM_P_RETR_CNTXT_19 (at 0xF9918834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_19"
        group.long 0x14838--0x1483B "BAM_P_SI_CNTXT_19 (at 0xF9918838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_19"
        group.long 0x14830--0x14833 "BAM_P_DF_CNTXT_19 (at 0xF9918830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_19"
        group.long 0x14804--0x14807 "BAM_P_AU_PSM_CNTXT_1_19 (at 0xF9918804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_19"
        group.long 0x14808--0x1480B "BAM_P_PSM_CNTXT_2_19 (at 0xF9918808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_19"
        group.long 0x1480C--0x1480F "BAM_P_PSM_CNTXT_3_19 (at 0xF991880C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_19"
        group.long 0x14810--0x14813 "BAM_P_PSM_CNTXT_4_19 (at 0xF9918810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_19"
        group.long 0x14814--0x14817 "BAM_P_PSM_CNTXT_5_19 (at 0xF9918814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 19
tree.end
tree "Pipe 20"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL20"
        group.long 0x15000--0x15003 "BAM_P_CTRL20 (at 0xF9919000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST20"
        group.long 0x15004--0x15007 "BAM_P_RST20 (at 0xF9919004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT20"
        group.long 0x15008--0x1500B "BAM_P_HALT20 (at 0xF9919008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG20"
        group.long 0x15030--0x15033 "BAM_P_TRUST_REG20 (at 0xF9919030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS20"
        group.long 0x15010--0x15013 "BAM_P_IRQ_STTS20 (at 0xF9919010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR20"
        group.long 0x15014--0x15017 "BAM_P_IRQ_CLR20 (at 0xF9919014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN20"
        group.long 0x15018--0x1501B "BAM_P_IRQ_EN20 (at 0xF9919018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER20"
        group.long 0x1501C--0x1501F "BAM_P_TIMER20 (at 0xF991901C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL20"
        group.long 0x15020--0x15023 "BAM_P_TIMER_CTRL20 (at 0xF9919020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND20"
        group.long 0x15024--0x15027 "BAM_P_PRDCR_SDBND20 (at 0xF9919024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND20"
        group.long 0x15028--0x1502B "BAM_P_CNSMR_SDBND20 (at 0xF9919028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR20"
        group.long 0x1582C--0x1582F "BAM_P_EVNT_DEST_ADDR20 (at 0xF991982C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG20"
        group.long 0x15818--0x1581B "BAM_P_EVNT_REG20 (at 0xF9919818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS20"
        group.long 0x15800--0x15803 "BAM_P_SW_OFSTS20 (at 0xF9919800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR20"
        group.long 0x15824--0x15827 "BAM_P_DATA_FIFO_ADDR20 (at 0xF9919824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR20"
        group.long 0x1581C--0x1581F "BAM_P_DESC_FIFO_ADDR20 (at 0xF991981C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD20"
        group.long 0x15828--0x1582B "BAM_P_EVNT_GEN_TRSHLD20 (at 0xF9919828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES20"
        group.long 0x15820--0x15823 "BAM_P_FIFO_SIZES20 (at 0xF9919820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_20"
        group.long 0x15834--0x15837 "BAM_P_RETR_CNTXT_20 (at 0xF9919834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_20"
        group.long 0x15838--0x1583B "BAM_P_SI_CNTXT_20 (at 0xF9919838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_20"
        group.long 0x15830--0x15833 "BAM_P_DF_CNTXT_20 (at 0xF9919830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_20"
        group.long 0x15804--0x15807 "BAM_P_AU_PSM_CNTXT_1_20 (at 0xF9919804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_20"
        group.long 0x15808--0x1580B "BAM_P_PSM_CNTXT_2_20 (at 0xF9919808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_20"
        group.long 0x1580C--0x1580F "BAM_P_PSM_CNTXT_3_20 (at 0xF991980C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_20"
        group.long 0x15810--0x15813 "BAM_P_PSM_CNTXT_4_20 (at 0xF9919810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_20"
        group.long 0x15814--0x15817 "BAM_P_PSM_CNTXT_5_20 (at 0xF9919814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 20
tree.end
tree "Pipe 21"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL21"
        group.long 0x16000--0x16003 "BAM_P_CTRL21 (at 0xF991A000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST21"
        group.long 0x16004--0x16007 "BAM_P_RST21 (at 0xF991A004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT21"
        group.long 0x16008--0x1600B "BAM_P_HALT21 (at 0xF991A008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG21"
        group.long 0x16030--0x16033 "BAM_P_TRUST_REG21 (at 0xF991A030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS21"
        group.long 0x16010--0x16013 "BAM_P_IRQ_STTS21 (at 0xF991A010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR21"
        group.long 0x16014--0x16017 "BAM_P_IRQ_CLR21 (at 0xF991A014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN21"
        group.long 0x16018--0x1601B "BAM_P_IRQ_EN21 (at 0xF991A018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER21"
        group.long 0x1601C--0x1601F "BAM_P_TIMER21 (at 0xF991A01C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL21"
        group.long 0x16020--0x16023 "BAM_P_TIMER_CTRL21 (at 0xF991A020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND21"
        group.long 0x16024--0x16027 "BAM_P_PRDCR_SDBND21 (at 0xF991A024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND21"
        group.long 0x16028--0x1602B "BAM_P_CNSMR_SDBND21 (at 0xF991A028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR21"
        group.long 0x1682C--0x1682F "BAM_P_EVNT_DEST_ADDR21 (at 0xF991A82C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG21"
        group.long 0x16818--0x1681B "BAM_P_EVNT_REG21 (at 0xF991A818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS21"
        group.long 0x16800--0x16803 "BAM_P_SW_OFSTS21 (at 0xF991A800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR21"
        group.long 0x16824--0x16827 "BAM_P_DATA_FIFO_ADDR21 (at 0xF991A824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR21"
        group.long 0x1681C--0x1681F "BAM_P_DESC_FIFO_ADDR21 (at 0xF991A81C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD21"
        group.long 0x16828--0x1682B "BAM_P_EVNT_GEN_TRSHLD21 (at 0xF991A828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES21"
        group.long 0x16820--0x16823 "BAM_P_FIFO_SIZES21 (at 0xF991A820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_21"
        group.long 0x16834--0x16837 "BAM_P_RETR_CNTXT_21 (at 0xF991A834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_21"
        group.long 0x16838--0x1683B "BAM_P_SI_CNTXT_21 (at 0xF991A838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_21"
        group.long 0x16830--0x16833 "BAM_P_DF_CNTXT_21 (at 0xF991A830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_21"
        group.long 0x16804--0x16807 "BAM_P_AU_PSM_CNTXT_1_21 (at 0xF991A804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_21"
        group.long 0x16808--0x1680B "BAM_P_PSM_CNTXT_2_21 (at 0xF991A808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_21"
        group.long 0x1680C--0x1680F "BAM_P_PSM_CNTXT_3_21 (at 0xF991A80C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_21"
        group.long 0x16810--0x16813 "BAM_P_PSM_CNTXT_4_21 (at 0xF991A810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_21"
        group.long 0x16814--0x16817 "BAM_P_PSM_CNTXT_5_21 (at 0xF991A814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 21
tree.end
tree "Pipe 22"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL22"
        group.long 0x17000--0x17003 "BAM_P_CTRL22 (at 0xF991B000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST22"
        group.long 0x17004--0x17007 "BAM_P_RST22 (at 0xF991B004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT22"
        group.long 0x17008--0x1700B "BAM_P_HALT22 (at 0xF991B008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG22"
        group.long 0x17030--0x17033 "BAM_P_TRUST_REG22 (at 0xF991B030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS22"
        group.long 0x17010--0x17013 "BAM_P_IRQ_STTS22 (at 0xF991B010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR22"
        group.long 0x17014--0x17017 "BAM_P_IRQ_CLR22 (at 0xF991B014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN22"
        group.long 0x17018--0x1701B "BAM_P_IRQ_EN22 (at 0xF991B018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER22"
        group.long 0x1701C--0x1701F "BAM_P_TIMER22 (at 0xF991B01C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL22"
        group.long 0x17020--0x17023 "BAM_P_TIMER_CTRL22 (at 0xF991B020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND22"
        group.long 0x17024--0x17027 "BAM_P_PRDCR_SDBND22 (at 0xF991B024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND22"
        group.long 0x17028--0x1702B "BAM_P_CNSMR_SDBND22 (at 0xF991B028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR22"
        group.long 0x1782C--0x1782F "BAM_P_EVNT_DEST_ADDR22 (at 0xF991B82C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG22"
        group.long 0x17818--0x1781B "BAM_P_EVNT_REG22 (at 0xF991B818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS22"
        group.long 0x17800--0x17803 "BAM_P_SW_OFSTS22 (at 0xF991B800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR22"
        group.long 0x17824--0x17827 "BAM_P_DATA_FIFO_ADDR22 (at 0xF991B824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR22"
        group.long 0x1781C--0x1781F "BAM_P_DESC_FIFO_ADDR22 (at 0xF991B81C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD22"
        group.long 0x17828--0x1782B "BAM_P_EVNT_GEN_TRSHLD22 (at 0xF991B828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES22"
        group.long 0x17820--0x17823 "BAM_P_FIFO_SIZES22 (at 0xF991B820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_22"
        group.long 0x17834--0x17837 "BAM_P_RETR_CNTXT_22 (at 0xF991B834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_22"
        group.long 0x17838--0x1783B "BAM_P_SI_CNTXT_22 (at 0xF991B838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_22"
        group.long 0x17830--0x17833 "BAM_P_DF_CNTXT_22 (at 0xF991B830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_22"
        group.long 0x17804--0x17807 "BAM_P_AU_PSM_CNTXT_1_22 (at 0xF991B804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_22"
        group.long 0x17808--0x1780B "BAM_P_PSM_CNTXT_2_22 (at 0xF991B808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_22"
        group.long 0x1780C--0x1780F "BAM_P_PSM_CNTXT_3_22 (at 0xF991B80C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_22"
        group.long 0x17810--0x17813 "BAM_P_PSM_CNTXT_4_22 (at 0xF991B810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_22"
        group.long 0x17814--0x17817 "BAM_P_PSM_CNTXT_5_22 (at 0xF991B814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 22
tree.end
tree "Pipe 23"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL23"
        group.long 0x18000--0x18003 "BAM_P_CTRL23 (at 0xF991C000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST23"
        group.long 0x18004--0x18007 "BAM_P_RST23 (at 0xF991C004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT23"
        group.long 0x18008--0x1800B "BAM_P_HALT23 (at 0xF991C008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG23"
        group.long 0x18030--0x18033 "BAM_P_TRUST_REG23 (at 0xF991C030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS23"
        group.long 0x18010--0x18013 "BAM_P_IRQ_STTS23 (at 0xF991C010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR23"
        group.long 0x18014--0x18017 "BAM_P_IRQ_CLR23 (at 0xF991C014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN23"
        group.long 0x18018--0x1801B "BAM_P_IRQ_EN23 (at 0xF991C018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER23"
        group.long 0x1801C--0x1801F "BAM_P_TIMER23 (at 0xF991C01C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL23"
        group.long 0x18020--0x18023 "BAM_P_TIMER_CTRL23 (at 0xF991C020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND23"
        group.long 0x18024--0x18027 "BAM_P_PRDCR_SDBND23 (at 0xF991C024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND23"
        group.long 0x18028--0x1802B "BAM_P_CNSMR_SDBND23 (at 0xF991C028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR23"
        group.long 0x1882C--0x1882F "BAM_P_EVNT_DEST_ADDR23 (at 0xF991C82C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG23"
        group.long 0x18818--0x1881B "BAM_P_EVNT_REG23 (at 0xF991C818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS23"
        group.long 0x18800--0x18803 "BAM_P_SW_OFSTS23 (at 0xF991C800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR23"
        group.long 0x18824--0x18827 "BAM_P_DATA_FIFO_ADDR23 (at 0xF991C824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR23"
        group.long 0x1881C--0x1881F "BAM_P_DESC_FIFO_ADDR23 (at 0xF991C81C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD23"
        group.long 0x18828--0x1882B "BAM_P_EVNT_GEN_TRSHLD23 (at 0xF991C828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES23"
        group.long 0x18820--0x18823 "BAM_P_FIFO_SIZES23 (at 0xF991C820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_23"
        group.long 0x18834--0x18837 "BAM_P_RETR_CNTXT_23 (at 0xF991C834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_23"
        group.long 0x18838--0x1883B "BAM_P_SI_CNTXT_23 (at 0xF991C838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_23"
        group.long 0x18830--0x18833 "BAM_P_DF_CNTXT_23 (at 0xF991C830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_23"
        group.long 0x18804--0x18807 "BAM_P_AU_PSM_CNTXT_1_23 (at 0xF991C804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_23"
        group.long 0x18808--0x1880B "BAM_P_PSM_CNTXT_2_23 (at 0xF991C808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_23"
        group.long 0x1880C--0x1880F "BAM_P_PSM_CNTXT_3_23 (at 0xF991C80C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_23"
        group.long 0x18810--0x18813 "BAM_P_PSM_CNTXT_4_23 (at 0xF991C810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_23"
        group.long 0x18814--0x18817 "BAM_P_PSM_CNTXT_5_23 (at 0xF991C814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 23
tree.end
tree.end
;Block Per Data Ends

base ad:0xF9944000
tree "BLSP2"
tree "BAM Control Registers"
      tree "BAM_CTRL"
        group.long 0x0--0x3 "BAM_CTRL (at 0xF9944000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x13 " [   19]   CACHE_MISS_ERR_RESP_EN                   = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11--0x12 " [18:17]   LOCAL_CLK_GATING                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   IBC_DISABLE                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0xF " [   15]   BAM_CACHED_DESC_STORE                    = "  "0,1"
        textline ""
        bitfld.long 0x0 0xD--0xE " [14:13]   BAM_DESC_CACHE_SEL                       = "  "0,1,2,3"
        textline ""
        hexmask.long.word 0x0 0x5--0xB 1  " [11:05]   BAM_TESTBUS_SEL                          = " 
        textline ""
        bitfld.long 0x0 0x4 " [   04]   BAM_EN_ACCUM                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_EN                                   = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   BAM_SW_RST                               = "  "0,1"
        textline ""
      tree.end
      tree "BAM_REVISION"
        group.long 0x4--0x7 "BAM_REVISION (at 0xF9944004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x18--0x1F 1  " [31:24]   INACTIV_TMR_BASE                         = " 
        textline ""
        bitfld.long 0x0 0x17 " [   23]   CMD_DESC_EN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15--0x16 " [22:21]   DESC_CACHE_DEPTH                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   NUM_INACTIV_TMRS                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x13 " [   19]   INACTIV_TMRS_EXST                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x12 " [   18]   HIGH_FREQUENCY_BAM                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11 " [   17]   BAM_HAS_NO_BYPASS                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   SECURED                                  = "  "0,1"
        textline ""
        bitfld.long 0x0 0xF " [   15]   USE_VMIDMT                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0xE " [   14]   AXI_ACTIVE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0xD " [   13]   CE_BUFFER_SIZE                           = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x8--0xB 1  " [11:08]   NUM_EES                                  = " 
        textline ""
        hexmask.long.word 0x0 0x0--0x7 1  " [07:00]   REVISION                                 = " 
        textline ""
      tree.end
      tree "BAM_SW_VERSION"
        group.long 0x80--0x83 "BAM_SW_VERSION (at 0xF9944080) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x1C--0x1F 1  " [31:28]   MAJOR                                    = " 
        textline ""
        hexmask.long.word 0x0 0x10--0x1B 1  " [27:16]   MINOR                                    = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   STEP                                     = " 
        textline ""
      tree.end
      tree "BAM_NUM_PIPES"
        group.long 0x3C--0x3F "BAM_NUM_PIPES (at 0xF994403C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x18--0x1F 1  " [31:24]   BAM_NON_PIPE_GRP                         = " 
        textline ""
        hexmask.long.word 0x0 0x10--0x17 1  " [23:16]   PERIPH_NON_PIPE_GRP                      = " 
        textline ""
        hexmask.long.word 0x0 0x0--0x7 1  " [07:00]   BAM_NUM_PIPES                            = " 
        textline ""
      tree.end
      tree "BAM_TIMER"
        group.long 0x40--0x43 "BAM_TIMER (at 0xF9944040) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   TIMER                                    = " 
        textline ""
      tree.end
      tree "BAM_TIMER_CTRL"
        group.long 0x44--0x47 "BAM_TIMER_CTRL (at 0xF9944044) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   TIMER_RST                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   TIMER_RUN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   TIMER_MODE                               = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   TIMER_TRSHLD                             = " 
        textline ""
      tree.end
      tree "BAM_DESC_CNT_TRSHLD"
        group.long 0x8--0xB "BAM_DESC_CNT_TRSHLD (at 0xF9944008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   CNT_TRSHLD                               = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS"
        group.long 0xC--0xF "BAM_IRQ_SRCS (at 0xF994400C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK"
        group.long 0x10--0x13 "BAM_IRQ_SRCS_MSK (at 0xF9944010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED"
        group.long 0x30--0x33 "BAM_IRQ_SRCS_UNMASKED (at 0xF9944030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_STTS"
        group.long 0x14--0x17 "BAM_IRQ_STTS (at 0xF9944014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x4 " [   04]   BAM_TIMER_IRQ                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   BAM_EMPTY_IRQ                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_ERROR_IRQ                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_HRESP_ERR_IRQ                        = "  "0,1"
        textline ""
      tree.end
      tree "BAM_IRQ_CLR"
        group.long 0x18--0x1B "BAM_IRQ_CLR (at 0xF9944018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x4 " [   04]   BAM_TIMER_CLR                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   BAM_EMPTY_CLR                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_ERROR_CLR                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_HRESP_ERR_CLR                        = "  "0,1"
        textline ""
      tree.end
      tree "BAM_IRQ_EN"
        group.long 0x1C--0x1F "BAM_IRQ_EN (at 0xF994401C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x4 " [   04]   BAM_TIMER_EN                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   BAM_EMPTY_EN                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_ERROR_EN                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_HRESP_ERR_EN                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_AHB_MASTER_ERR_CTRLS"
        group.long 0x24--0x27 "BAM_AHB_MASTER_ERR_CTRLS (at 0xF9944024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x12--0x16 1  " [22:18]   BAM_ERR_HVMID                            = " 
        textline ""
        bitfld.long 0x0 0x11 " [   17]   BAM_ERR_DIRECT_MODE                      = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0xC--0x10 1  " [16:12]   BAM_ERR_HCID                             = " 
        textline ""
        hexmask.long.word 0x0 0x8--0xB 1  " [11:08]   BAM_ERR_HPROT                            = " 
        textline ""
        bitfld.long 0x0 0x5--0x7 " [07:05]   BAM_ERR_HBURST                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x3--0x4 " [04:03]   BAM_ERR_HSIZE                            = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_ERR_HWRITE                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0--0x1 " [01:00]   BAM_ERR_HTRANS                           = "  "0,1,2,3"
        textline ""
      tree.end
      tree "BAM_AHB_MASTER_ERR_ADDR"
        group.long 0x28--0x2B "BAM_AHB_MASTER_ERR_ADDR (at 0xF9944028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   BAM_ERR_ADDR                             = " 
        textline ""
      tree.end
      tree "BAM_AHB_MASTER_ERR_DATA"
        group.long 0x2C--0x2F "BAM_AHB_MASTER_ERR_DATA (at 0xF994402C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   BAM_ERR_DATA                             = " 
        textline ""
      tree.end
      tree "BAM_TRUST_REG"
        group.long 0x70--0x73 "BAM_TRUST_REG (at 0xF9944070) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0xD " [   13]   LOCK_EE_CTRL                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_VMID                                 = " 
        textline ""
        bitfld.long 0x0 0x7 " [   07]   BAM_RST_BLOCK                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_EE                                   = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_TEST_BUS_SEL"
        group.long 0x74--0x77 "BAM_TEST_BUS_SEL (at 0xF9944074) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x15 " [   21]   SW_EVENTS_ZERO                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x13--0x14 " [20:19]   SW_EVENTS_SEL                            = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x12 " [   18]   BAM_DATA_ERASE                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11 " [   17]   BAM_DATA_FLUSH                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   BAM_CLK_ALWAYS_ON                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x0--0x6 1  " [06:00]   BAM_TESTBUS_SEL                          = " 
        textline ""
      tree.end
      tree "BAM_TEST_BUS_REG"
        group.long 0x78--0x7B "BAM_TEST_BUS_REG (at 0xF9944078) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   BAM_TESTBUS_REG                          = " 
        textline ""
      tree.end
      tree "BAM_CNFG_BITS"
        group.long 0x7C--0x7F "BAM_CNFG_BITS (at 0xF994407C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1C " [   28]   BAM_ZLT_W_CD_SUPPORT                     = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1B " [   27]   BAM_CD_ENABLE                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1A " [   26]   BAM_AU_ACCUMED                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x19 " [   25]   BAM_PSM_P_HD_DATA                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_REG_P_EN                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_WB_DSC_AVL_P_RST                     = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_WB_RETR_SVPNT                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_WB_CSW_ACK_IDL                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_WB_BLK_CSW                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x13 " [   19]   BAM_WB_P_RES                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x12 " [   18]   BAM_SI_P_RES                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11 " [   17]   BAM_AU_P_RES                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   BAM_PSM_P_RES                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0xF " [   15]   BAM_PSM_CSW_REQ                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0xE " [   14]   BAM_SB_CLK_REQ                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0xD " [   13]   BAM_IBC_DISABLE                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0xC " [   12]   BAM_NO_EXT_P_RST                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0xB " [   11]   BAM_FULL_PIPE                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   BAM_ADML_SYNC_BRIDGE                     = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_PIPE_CNFG                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_ADML_DEEP_CONS_FIFO                  = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   BAM_ADML_INCR4_EN_N                      = "  "0,1"
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE0"
        group.long 0x800--0x803 "BAM_IRQ_SRCS_EE0 (at 0xF9944800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE1"
        group.long 0x880--0x883 "BAM_IRQ_SRCS_EE1 (at 0xF9944880) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE2"
        group.long 0x900--0x903 "BAM_IRQ_SRCS_EE2 (at 0xF9944900) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE3"
        group.long 0x980--0x983 "BAM_IRQ_SRCS_EE3 (at 0xF9944980) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE4"
        group.long 0xA00--0xA03 "BAM_IRQ_SRCS_EE4 (at 0xF9944A00) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE5"
        group.long 0xA80--0xA83 "BAM_IRQ_SRCS_EE5 (at 0xF9944A80) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE6"
        group.long 0xB00--0xB03 "BAM_IRQ_SRCS_EE6 (at 0xF9944B00) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE7"
        group.long 0xB80--0xB83 "BAM_IRQ_SRCS_EE7 (at 0xF9944B80) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE0"
        group.long 0x804--0x807 "BAM_IRQ_SRCS_MSK_EE0 (at 0xF9944804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE1"
        group.long 0x884--0x887 "BAM_IRQ_SRCS_MSK_EE1 (at 0xF9944884) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE2"
        group.long 0x904--0x907 "BAM_IRQ_SRCS_MSK_EE2 (at 0xF9944904) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE3"
        group.long 0x984--0x987 "BAM_IRQ_SRCS_MSK_EE3 (at 0xF9944984) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE4"
        group.long 0xA04--0xA07 "BAM_IRQ_SRCS_MSK_EE4 (at 0xF9944A04) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE5"
        group.long 0xA84--0xA87 "BAM_IRQ_SRCS_MSK_EE5 (at 0xF9944A84) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE6"
        group.long 0xB04--0xB07 "BAM_IRQ_SRCS_MSK_EE6 (at 0xF9944B04) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE7"
        group.long 0xB84--0xB87 "BAM_IRQ_SRCS_MSK_EE7 (at 0xF9944B84) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE0"
        group.long 0x808--0x80B "BAM_IRQ_SRCS_UNMASKED_EE0 (at 0xF9944808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE1"
        group.long 0x888--0x88B "BAM_IRQ_SRCS_UNMASKED_EE1 (at 0xF9944888) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE2"
        group.long 0x908--0x90B "BAM_IRQ_SRCS_UNMASKED_EE2 (at 0xF9944908) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE3"
        group.long 0x988--0x98B "BAM_IRQ_SRCS_UNMASKED_EE3 (at 0xF9944988) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE4"
        group.long 0xA08--0xA0B "BAM_IRQ_SRCS_UNMASKED_EE4 (at 0xF9944A08) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE5"
        group.long 0xA88--0xA8B "BAM_IRQ_SRCS_UNMASKED_EE5 (at 0xF9944A88) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE6"
        group.long 0xB08--0xB0B "BAM_IRQ_SRCS_UNMASKED_EE6 (at 0xF9944B08) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE7"
        group.long 0xB88--0xB8B "BAM_IRQ_SRCS_UNMASKED_EE7 (at 0xF9944B88) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
;End of BAM Control Registers
tree.end
tree "Pipe 0"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL0"
        group.long 0x1000--0x1003 "BAM_P_CTRL0 (at 0xF9945000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST0"
        group.long 0x1004--0x1007 "BAM_P_RST0 (at 0xF9945004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT0"
        group.long 0x1008--0x100B "BAM_P_HALT0 (at 0xF9945008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG0"
        group.long 0x1030--0x1033 "BAM_P_TRUST_REG0 (at 0xF9945030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS0"
        group.long 0x1010--0x1013 "BAM_P_IRQ_STTS0 (at 0xF9945010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR0"
        group.long 0x1014--0x1017 "BAM_P_IRQ_CLR0 (at 0xF9945014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN0"
        group.long 0x1018--0x101B "BAM_P_IRQ_EN0 (at 0xF9945018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER0"
        group.long 0x101C--0x101F "BAM_P_TIMER0 (at 0xF994501C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL0"
        group.long 0x1020--0x1023 "BAM_P_TIMER_CTRL0 (at 0xF9945020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND0"
        group.long 0x1024--0x1027 "BAM_P_PRDCR_SDBND0 (at 0xF9945024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND0"
        group.long 0x1028--0x102B "BAM_P_CNSMR_SDBND0 (at 0xF9945028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR0"
        group.long 0x182C--0x182F "BAM_P_EVNT_DEST_ADDR0 (at 0xF994582C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG0"
        group.long 0x1818--0x181B "BAM_P_EVNT_REG0 (at 0xF9945818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS0"
        group.long 0x1800--0x1803 "BAM_P_SW_OFSTS0 (at 0xF9945800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR0"
        group.long 0x1824--0x1827 "BAM_P_DATA_FIFO_ADDR0 (at 0xF9945824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR0"
        group.long 0x181C--0x181F "BAM_P_DESC_FIFO_ADDR0 (at 0xF994581C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD0"
        group.long 0x1828--0x182B "BAM_P_EVNT_GEN_TRSHLD0 (at 0xF9945828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES0"
        group.long 0x1820--0x1823 "BAM_P_FIFO_SIZES0 (at 0xF9945820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_0"
        group.long 0x1834--0x1837 "BAM_P_RETR_CNTXT_0 (at 0xF9945834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_0"
        group.long 0x1838--0x183B "BAM_P_SI_CNTXT_0 (at 0xF9945838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_0"
        group.long 0x1830--0x1833 "BAM_P_DF_CNTXT_0 (at 0xF9945830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_0"
        group.long 0x1804--0x1807 "BAM_P_AU_PSM_CNTXT_1_0 (at 0xF9945804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_0"
        group.long 0x1808--0x180B "BAM_P_PSM_CNTXT_2_0 (at 0xF9945808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_0"
        group.long 0x180C--0x180F "BAM_P_PSM_CNTXT_3_0 (at 0xF994580C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_0"
        group.long 0x1810--0x1813 "BAM_P_PSM_CNTXT_4_0 (at 0xF9945810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_0"
        group.long 0x1814--0x1817 "BAM_P_PSM_CNTXT_5_0 (at 0xF9945814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 0
tree.end
tree "Pipe 1"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL1"
        group.long 0x2000--0x2003 "BAM_P_CTRL1 (at 0xF9946000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST1"
        group.long 0x2004--0x2007 "BAM_P_RST1 (at 0xF9946004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT1"
        group.long 0x2008--0x200B "BAM_P_HALT1 (at 0xF9946008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG1"
        group.long 0x2030--0x2033 "BAM_P_TRUST_REG1 (at 0xF9946030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS1"
        group.long 0x2010--0x2013 "BAM_P_IRQ_STTS1 (at 0xF9946010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR1"
        group.long 0x2014--0x2017 "BAM_P_IRQ_CLR1 (at 0xF9946014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN1"
        group.long 0x2018--0x201B "BAM_P_IRQ_EN1 (at 0xF9946018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER1"
        group.long 0x201C--0x201F "BAM_P_TIMER1 (at 0xF994601C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL1"
        group.long 0x2020--0x2023 "BAM_P_TIMER_CTRL1 (at 0xF9946020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND1"
        group.long 0x2024--0x2027 "BAM_P_PRDCR_SDBND1 (at 0xF9946024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND1"
        group.long 0x2028--0x202B "BAM_P_CNSMR_SDBND1 (at 0xF9946028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR1"
        group.long 0x282C--0x282F "BAM_P_EVNT_DEST_ADDR1 (at 0xF994682C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG1"
        group.long 0x2818--0x281B "BAM_P_EVNT_REG1 (at 0xF9946818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS1"
        group.long 0x2800--0x2803 "BAM_P_SW_OFSTS1 (at 0xF9946800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR1"
        group.long 0x2824--0x2827 "BAM_P_DATA_FIFO_ADDR1 (at 0xF9946824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR1"
        group.long 0x281C--0x281F "BAM_P_DESC_FIFO_ADDR1 (at 0xF994681C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD1"
        group.long 0x2828--0x282B "BAM_P_EVNT_GEN_TRSHLD1 (at 0xF9946828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES1"
        group.long 0x2820--0x2823 "BAM_P_FIFO_SIZES1 (at 0xF9946820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_1"
        group.long 0x2834--0x2837 "BAM_P_RETR_CNTXT_1 (at 0xF9946834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_1"
        group.long 0x2838--0x283B "BAM_P_SI_CNTXT_1 (at 0xF9946838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_1"
        group.long 0x2830--0x2833 "BAM_P_DF_CNTXT_1 (at 0xF9946830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_1"
        group.long 0x2804--0x2807 "BAM_P_AU_PSM_CNTXT_1_1 (at 0xF9946804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_1"
        group.long 0x2808--0x280B "BAM_P_PSM_CNTXT_2_1 (at 0xF9946808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_1"
        group.long 0x280C--0x280F "BAM_P_PSM_CNTXT_3_1 (at 0xF994680C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_1"
        group.long 0x2810--0x2813 "BAM_P_PSM_CNTXT_4_1 (at 0xF9946810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_1"
        group.long 0x2814--0x2817 "BAM_P_PSM_CNTXT_5_1 (at 0xF9946814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 1
tree.end
tree "Pipe 2"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL2"
        group.long 0x3000--0x3003 "BAM_P_CTRL2 (at 0xF9947000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST2"
        group.long 0x3004--0x3007 "BAM_P_RST2 (at 0xF9947004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT2"
        group.long 0x3008--0x300B "BAM_P_HALT2 (at 0xF9947008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG2"
        group.long 0x3030--0x3033 "BAM_P_TRUST_REG2 (at 0xF9947030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS2"
        group.long 0x3010--0x3013 "BAM_P_IRQ_STTS2 (at 0xF9947010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR2"
        group.long 0x3014--0x3017 "BAM_P_IRQ_CLR2 (at 0xF9947014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN2"
        group.long 0x3018--0x301B "BAM_P_IRQ_EN2 (at 0xF9947018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER2"
        group.long 0x301C--0x301F "BAM_P_TIMER2 (at 0xF994701C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL2"
        group.long 0x3020--0x3023 "BAM_P_TIMER_CTRL2 (at 0xF9947020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND2"
        group.long 0x3024--0x3027 "BAM_P_PRDCR_SDBND2 (at 0xF9947024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND2"
        group.long 0x3028--0x302B "BAM_P_CNSMR_SDBND2 (at 0xF9947028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR2"
        group.long 0x382C--0x382F "BAM_P_EVNT_DEST_ADDR2 (at 0xF994782C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG2"
        group.long 0x3818--0x381B "BAM_P_EVNT_REG2 (at 0xF9947818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS2"
        group.long 0x3800--0x3803 "BAM_P_SW_OFSTS2 (at 0xF9947800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR2"
        group.long 0x3824--0x3827 "BAM_P_DATA_FIFO_ADDR2 (at 0xF9947824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR2"
        group.long 0x381C--0x381F "BAM_P_DESC_FIFO_ADDR2 (at 0xF994781C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD2"
        group.long 0x3828--0x382B "BAM_P_EVNT_GEN_TRSHLD2 (at 0xF9947828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES2"
        group.long 0x3820--0x3823 "BAM_P_FIFO_SIZES2 (at 0xF9947820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_2"
        group.long 0x3834--0x3837 "BAM_P_RETR_CNTXT_2 (at 0xF9947834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_2"
        group.long 0x3838--0x383B "BAM_P_SI_CNTXT_2 (at 0xF9947838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_2"
        group.long 0x3830--0x3833 "BAM_P_DF_CNTXT_2 (at 0xF9947830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_2"
        group.long 0x3804--0x3807 "BAM_P_AU_PSM_CNTXT_1_2 (at 0xF9947804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_2"
        group.long 0x3808--0x380B "BAM_P_PSM_CNTXT_2_2 (at 0xF9947808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_2"
        group.long 0x380C--0x380F "BAM_P_PSM_CNTXT_3_2 (at 0xF994780C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_2"
        group.long 0x3810--0x3813 "BAM_P_PSM_CNTXT_4_2 (at 0xF9947810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_2"
        group.long 0x3814--0x3817 "BAM_P_PSM_CNTXT_5_2 (at 0xF9947814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 2
tree.end
tree "Pipe 3"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL3"
        group.long 0x4000--0x4003 "BAM_P_CTRL3 (at 0xF9948000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST3"
        group.long 0x4004--0x4007 "BAM_P_RST3 (at 0xF9948004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT3"
        group.long 0x4008--0x400B "BAM_P_HALT3 (at 0xF9948008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG3"
        group.long 0x4030--0x4033 "BAM_P_TRUST_REG3 (at 0xF9948030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS3"
        group.long 0x4010--0x4013 "BAM_P_IRQ_STTS3 (at 0xF9948010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR3"
        group.long 0x4014--0x4017 "BAM_P_IRQ_CLR3 (at 0xF9948014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN3"
        group.long 0x4018--0x401B "BAM_P_IRQ_EN3 (at 0xF9948018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER3"
        group.long 0x401C--0x401F "BAM_P_TIMER3 (at 0xF994801C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL3"
        group.long 0x4020--0x4023 "BAM_P_TIMER_CTRL3 (at 0xF9948020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND3"
        group.long 0x4024--0x4027 "BAM_P_PRDCR_SDBND3 (at 0xF9948024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND3"
        group.long 0x4028--0x402B "BAM_P_CNSMR_SDBND3 (at 0xF9948028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR3"
        group.long 0x482C--0x482F "BAM_P_EVNT_DEST_ADDR3 (at 0xF994882C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG3"
        group.long 0x4818--0x481B "BAM_P_EVNT_REG3 (at 0xF9948818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS3"
        group.long 0x4800--0x4803 "BAM_P_SW_OFSTS3 (at 0xF9948800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR3"
        group.long 0x4824--0x4827 "BAM_P_DATA_FIFO_ADDR3 (at 0xF9948824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR3"
        group.long 0x481C--0x481F "BAM_P_DESC_FIFO_ADDR3 (at 0xF994881C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD3"
        group.long 0x4828--0x482B "BAM_P_EVNT_GEN_TRSHLD3 (at 0xF9948828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES3"
        group.long 0x4820--0x4823 "BAM_P_FIFO_SIZES3 (at 0xF9948820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_3"
        group.long 0x4834--0x4837 "BAM_P_RETR_CNTXT_3 (at 0xF9948834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_3"
        group.long 0x4838--0x483B "BAM_P_SI_CNTXT_3 (at 0xF9948838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_3"
        group.long 0x4830--0x4833 "BAM_P_DF_CNTXT_3 (at 0xF9948830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_3"
        group.long 0x4804--0x4807 "BAM_P_AU_PSM_CNTXT_1_3 (at 0xF9948804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_3"
        group.long 0x4808--0x480B "BAM_P_PSM_CNTXT_2_3 (at 0xF9948808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_3"
        group.long 0x480C--0x480F "BAM_P_PSM_CNTXT_3_3 (at 0xF994880C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_3"
        group.long 0x4810--0x4813 "BAM_P_PSM_CNTXT_4_3 (at 0xF9948810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_3"
        group.long 0x4814--0x4817 "BAM_P_PSM_CNTXT_5_3 (at 0xF9948814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 3
tree.end
tree "Pipe 4"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL4"
        group.long 0x5000--0x5003 "BAM_P_CTRL4 (at 0xF9949000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST4"
        group.long 0x5004--0x5007 "BAM_P_RST4 (at 0xF9949004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT4"
        group.long 0x5008--0x500B "BAM_P_HALT4 (at 0xF9949008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG4"
        group.long 0x5030--0x5033 "BAM_P_TRUST_REG4 (at 0xF9949030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS4"
        group.long 0x5010--0x5013 "BAM_P_IRQ_STTS4 (at 0xF9949010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR4"
        group.long 0x5014--0x5017 "BAM_P_IRQ_CLR4 (at 0xF9949014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN4"
        group.long 0x5018--0x501B "BAM_P_IRQ_EN4 (at 0xF9949018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER4"
        group.long 0x501C--0x501F "BAM_P_TIMER4 (at 0xF994901C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL4"
        group.long 0x5020--0x5023 "BAM_P_TIMER_CTRL4 (at 0xF9949020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND4"
        group.long 0x5024--0x5027 "BAM_P_PRDCR_SDBND4 (at 0xF9949024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND4"
        group.long 0x5028--0x502B "BAM_P_CNSMR_SDBND4 (at 0xF9949028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR4"
        group.long 0x582C--0x582F "BAM_P_EVNT_DEST_ADDR4 (at 0xF994982C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG4"
        group.long 0x5818--0x581B "BAM_P_EVNT_REG4 (at 0xF9949818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS4"
        group.long 0x5800--0x5803 "BAM_P_SW_OFSTS4 (at 0xF9949800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR4"
        group.long 0x5824--0x5827 "BAM_P_DATA_FIFO_ADDR4 (at 0xF9949824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR4"
        group.long 0x581C--0x581F "BAM_P_DESC_FIFO_ADDR4 (at 0xF994981C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD4"
        group.long 0x5828--0x582B "BAM_P_EVNT_GEN_TRSHLD4 (at 0xF9949828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES4"
        group.long 0x5820--0x5823 "BAM_P_FIFO_SIZES4 (at 0xF9949820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_4"
        group.long 0x5834--0x5837 "BAM_P_RETR_CNTXT_4 (at 0xF9949834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_4"
        group.long 0x5838--0x583B "BAM_P_SI_CNTXT_4 (at 0xF9949838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_4"
        group.long 0x5830--0x5833 "BAM_P_DF_CNTXT_4 (at 0xF9949830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_4"
        group.long 0x5804--0x5807 "BAM_P_AU_PSM_CNTXT_1_4 (at 0xF9949804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_4"
        group.long 0x5808--0x580B "BAM_P_PSM_CNTXT_2_4 (at 0xF9949808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_4"
        group.long 0x580C--0x580F "BAM_P_PSM_CNTXT_3_4 (at 0xF994980C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_4"
        group.long 0x5810--0x5813 "BAM_P_PSM_CNTXT_4_4 (at 0xF9949810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_4"
        group.long 0x5814--0x5817 "BAM_P_PSM_CNTXT_5_4 (at 0xF9949814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 4
tree.end
tree "Pipe 5"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL5"
        group.long 0x6000--0x6003 "BAM_P_CTRL5 (at 0xF994A000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST5"
        group.long 0x6004--0x6007 "BAM_P_RST5 (at 0xF994A004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT5"
        group.long 0x6008--0x600B "BAM_P_HALT5 (at 0xF994A008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG5"
        group.long 0x6030--0x6033 "BAM_P_TRUST_REG5 (at 0xF994A030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS5"
        group.long 0x6010--0x6013 "BAM_P_IRQ_STTS5 (at 0xF994A010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR5"
        group.long 0x6014--0x6017 "BAM_P_IRQ_CLR5 (at 0xF994A014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN5"
        group.long 0x6018--0x601B "BAM_P_IRQ_EN5 (at 0xF994A018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER5"
        group.long 0x601C--0x601F "BAM_P_TIMER5 (at 0xF994A01C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL5"
        group.long 0x6020--0x6023 "BAM_P_TIMER_CTRL5 (at 0xF994A020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND5"
        group.long 0x6024--0x6027 "BAM_P_PRDCR_SDBND5 (at 0xF994A024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND5"
        group.long 0x6028--0x602B "BAM_P_CNSMR_SDBND5 (at 0xF994A028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR5"
        group.long 0x682C--0x682F "BAM_P_EVNT_DEST_ADDR5 (at 0xF994A82C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG5"
        group.long 0x6818--0x681B "BAM_P_EVNT_REG5 (at 0xF994A818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS5"
        group.long 0x6800--0x6803 "BAM_P_SW_OFSTS5 (at 0xF994A800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR5"
        group.long 0x6824--0x6827 "BAM_P_DATA_FIFO_ADDR5 (at 0xF994A824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR5"
        group.long 0x681C--0x681F "BAM_P_DESC_FIFO_ADDR5 (at 0xF994A81C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD5"
        group.long 0x6828--0x682B "BAM_P_EVNT_GEN_TRSHLD5 (at 0xF994A828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES5"
        group.long 0x6820--0x6823 "BAM_P_FIFO_SIZES5 (at 0xF994A820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_5"
        group.long 0x6834--0x6837 "BAM_P_RETR_CNTXT_5 (at 0xF994A834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_5"
        group.long 0x6838--0x683B "BAM_P_SI_CNTXT_5 (at 0xF994A838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_5"
        group.long 0x6830--0x6833 "BAM_P_DF_CNTXT_5 (at 0xF994A830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_5"
        group.long 0x6804--0x6807 "BAM_P_AU_PSM_CNTXT_1_5 (at 0xF994A804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_5"
        group.long 0x6808--0x680B "BAM_P_PSM_CNTXT_2_5 (at 0xF994A808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_5"
        group.long 0x680C--0x680F "BAM_P_PSM_CNTXT_3_5 (at 0xF994A80C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_5"
        group.long 0x6810--0x6813 "BAM_P_PSM_CNTXT_4_5 (at 0xF994A810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_5"
        group.long 0x6814--0x6817 "BAM_P_PSM_CNTXT_5_5 (at 0xF994A814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 5
tree.end
tree "Pipe 6"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL6"
        group.long 0x7000--0x7003 "BAM_P_CTRL6 (at 0xF994B000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST6"
        group.long 0x7004--0x7007 "BAM_P_RST6 (at 0xF994B004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT6"
        group.long 0x7008--0x700B "BAM_P_HALT6 (at 0xF994B008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG6"
        group.long 0x7030--0x7033 "BAM_P_TRUST_REG6 (at 0xF994B030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS6"
        group.long 0x7010--0x7013 "BAM_P_IRQ_STTS6 (at 0xF994B010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR6"
        group.long 0x7014--0x7017 "BAM_P_IRQ_CLR6 (at 0xF994B014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN6"
        group.long 0x7018--0x701B "BAM_P_IRQ_EN6 (at 0xF994B018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER6"
        group.long 0x701C--0x701F "BAM_P_TIMER6 (at 0xF994B01C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL6"
        group.long 0x7020--0x7023 "BAM_P_TIMER_CTRL6 (at 0xF994B020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND6"
        group.long 0x7024--0x7027 "BAM_P_PRDCR_SDBND6 (at 0xF994B024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND6"
        group.long 0x7028--0x702B "BAM_P_CNSMR_SDBND6 (at 0xF994B028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR6"
        group.long 0x782C--0x782F "BAM_P_EVNT_DEST_ADDR6 (at 0xF994B82C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG6"
        group.long 0x7818--0x781B "BAM_P_EVNT_REG6 (at 0xF994B818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS6"
        group.long 0x7800--0x7803 "BAM_P_SW_OFSTS6 (at 0xF994B800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR6"
        group.long 0x7824--0x7827 "BAM_P_DATA_FIFO_ADDR6 (at 0xF994B824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR6"
        group.long 0x781C--0x781F "BAM_P_DESC_FIFO_ADDR6 (at 0xF994B81C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD6"
        group.long 0x7828--0x782B "BAM_P_EVNT_GEN_TRSHLD6 (at 0xF994B828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES6"
        group.long 0x7820--0x7823 "BAM_P_FIFO_SIZES6 (at 0xF994B820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_6"
        group.long 0x7834--0x7837 "BAM_P_RETR_CNTXT_6 (at 0xF994B834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_6"
        group.long 0x7838--0x783B "BAM_P_SI_CNTXT_6 (at 0xF994B838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_6"
        group.long 0x7830--0x7833 "BAM_P_DF_CNTXT_6 (at 0xF994B830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_6"
        group.long 0x7804--0x7807 "BAM_P_AU_PSM_CNTXT_1_6 (at 0xF994B804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_6"
        group.long 0x7808--0x780B "BAM_P_PSM_CNTXT_2_6 (at 0xF994B808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_6"
        group.long 0x780C--0x780F "BAM_P_PSM_CNTXT_3_6 (at 0xF994B80C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_6"
        group.long 0x7810--0x7813 "BAM_P_PSM_CNTXT_4_6 (at 0xF994B810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_6"
        group.long 0x7814--0x7817 "BAM_P_PSM_CNTXT_5_6 (at 0xF994B814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 6
tree.end
tree "Pipe 7"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL7"
        group.long 0x8000--0x8003 "BAM_P_CTRL7 (at 0xF994C000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST7"
        group.long 0x8004--0x8007 "BAM_P_RST7 (at 0xF994C004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT7"
        group.long 0x8008--0x800B "BAM_P_HALT7 (at 0xF994C008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG7"
        group.long 0x8030--0x8033 "BAM_P_TRUST_REG7 (at 0xF994C030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS7"
        group.long 0x8010--0x8013 "BAM_P_IRQ_STTS7 (at 0xF994C010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR7"
        group.long 0x8014--0x8017 "BAM_P_IRQ_CLR7 (at 0xF994C014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN7"
        group.long 0x8018--0x801B "BAM_P_IRQ_EN7 (at 0xF994C018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER7"
        group.long 0x801C--0x801F "BAM_P_TIMER7 (at 0xF994C01C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL7"
        group.long 0x8020--0x8023 "BAM_P_TIMER_CTRL7 (at 0xF994C020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND7"
        group.long 0x8024--0x8027 "BAM_P_PRDCR_SDBND7 (at 0xF994C024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND7"
        group.long 0x8028--0x802B "BAM_P_CNSMR_SDBND7 (at 0xF994C028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR7"
        group.long 0x882C--0x882F "BAM_P_EVNT_DEST_ADDR7 (at 0xF994C82C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG7"
        group.long 0x8818--0x881B "BAM_P_EVNT_REG7 (at 0xF994C818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS7"
        group.long 0x8800--0x8803 "BAM_P_SW_OFSTS7 (at 0xF994C800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR7"
        group.long 0x8824--0x8827 "BAM_P_DATA_FIFO_ADDR7 (at 0xF994C824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR7"
        group.long 0x881C--0x881F "BAM_P_DESC_FIFO_ADDR7 (at 0xF994C81C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD7"
        group.long 0x8828--0x882B "BAM_P_EVNT_GEN_TRSHLD7 (at 0xF994C828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES7"
        group.long 0x8820--0x8823 "BAM_P_FIFO_SIZES7 (at 0xF994C820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_7"
        group.long 0x8834--0x8837 "BAM_P_RETR_CNTXT_7 (at 0xF994C834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_7"
        group.long 0x8838--0x883B "BAM_P_SI_CNTXT_7 (at 0xF994C838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_7"
        group.long 0x8830--0x8833 "BAM_P_DF_CNTXT_7 (at 0xF994C830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_7"
        group.long 0x8804--0x8807 "BAM_P_AU_PSM_CNTXT_1_7 (at 0xF994C804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_7"
        group.long 0x8808--0x880B "BAM_P_PSM_CNTXT_2_7 (at 0xF994C808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_7"
        group.long 0x880C--0x880F "BAM_P_PSM_CNTXT_3_7 (at 0xF994C80C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_7"
        group.long 0x8810--0x8813 "BAM_P_PSM_CNTXT_4_7 (at 0xF994C810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_7"
        group.long 0x8814--0x8817 "BAM_P_PSM_CNTXT_5_7 (at 0xF994C814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 7
tree.end
tree "Pipe 8"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL8"
        group.long 0x9000--0x9003 "BAM_P_CTRL8 (at 0xF994D000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST8"
        group.long 0x9004--0x9007 "BAM_P_RST8 (at 0xF994D004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT8"
        group.long 0x9008--0x900B "BAM_P_HALT8 (at 0xF994D008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG8"
        group.long 0x9030--0x9033 "BAM_P_TRUST_REG8 (at 0xF994D030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS8"
        group.long 0x9010--0x9013 "BAM_P_IRQ_STTS8 (at 0xF994D010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR8"
        group.long 0x9014--0x9017 "BAM_P_IRQ_CLR8 (at 0xF994D014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN8"
        group.long 0x9018--0x901B "BAM_P_IRQ_EN8 (at 0xF994D018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER8"
        group.long 0x901C--0x901F "BAM_P_TIMER8 (at 0xF994D01C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL8"
        group.long 0x9020--0x9023 "BAM_P_TIMER_CTRL8 (at 0xF994D020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND8"
        group.long 0x9024--0x9027 "BAM_P_PRDCR_SDBND8 (at 0xF994D024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND8"
        group.long 0x9028--0x902B "BAM_P_CNSMR_SDBND8 (at 0xF994D028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR8"
        group.long 0x982C--0x982F "BAM_P_EVNT_DEST_ADDR8 (at 0xF994D82C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG8"
        group.long 0x9818--0x981B "BAM_P_EVNT_REG8 (at 0xF994D818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS8"
        group.long 0x9800--0x9803 "BAM_P_SW_OFSTS8 (at 0xF994D800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR8"
        group.long 0x9824--0x9827 "BAM_P_DATA_FIFO_ADDR8 (at 0xF994D824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR8"
        group.long 0x981C--0x981F "BAM_P_DESC_FIFO_ADDR8 (at 0xF994D81C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD8"
        group.long 0x9828--0x982B "BAM_P_EVNT_GEN_TRSHLD8 (at 0xF994D828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES8"
        group.long 0x9820--0x9823 "BAM_P_FIFO_SIZES8 (at 0xF994D820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_8"
        group.long 0x9834--0x9837 "BAM_P_RETR_CNTXT_8 (at 0xF994D834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_8"
        group.long 0x9838--0x983B "BAM_P_SI_CNTXT_8 (at 0xF994D838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_8"
        group.long 0x9830--0x9833 "BAM_P_DF_CNTXT_8 (at 0xF994D830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_8"
        group.long 0x9804--0x9807 "BAM_P_AU_PSM_CNTXT_1_8 (at 0xF994D804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_8"
        group.long 0x9808--0x980B "BAM_P_PSM_CNTXT_2_8 (at 0xF994D808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_8"
        group.long 0x980C--0x980F "BAM_P_PSM_CNTXT_3_8 (at 0xF994D80C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_8"
        group.long 0x9810--0x9813 "BAM_P_PSM_CNTXT_4_8 (at 0xF994D810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_8"
        group.long 0x9814--0x9817 "BAM_P_PSM_CNTXT_5_8 (at 0xF994D814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 8
tree.end
tree "Pipe 9"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL9"
        group.long 0xA000--0xA003 "BAM_P_CTRL9 (at 0xF994E000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST9"
        group.long 0xA004--0xA007 "BAM_P_RST9 (at 0xF994E004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT9"
        group.long 0xA008--0xA00B "BAM_P_HALT9 (at 0xF994E008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG9"
        group.long 0xA030--0xA033 "BAM_P_TRUST_REG9 (at 0xF994E030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS9"
        group.long 0xA010--0xA013 "BAM_P_IRQ_STTS9 (at 0xF994E010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR9"
        group.long 0xA014--0xA017 "BAM_P_IRQ_CLR9 (at 0xF994E014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN9"
        group.long 0xA018--0xA01B "BAM_P_IRQ_EN9 (at 0xF994E018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER9"
        group.long 0xA01C--0xA01F "BAM_P_TIMER9 (at 0xF994E01C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL9"
        group.long 0xA020--0xA023 "BAM_P_TIMER_CTRL9 (at 0xF994E020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND9"
        group.long 0xA024--0xA027 "BAM_P_PRDCR_SDBND9 (at 0xF994E024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND9"
        group.long 0xA028--0xA02B "BAM_P_CNSMR_SDBND9 (at 0xF994E028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR9"
        group.long 0xA82C--0xA82F "BAM_P_EVNT_DEST_ADDR9 (at 0xF994E82C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG9"
        group.long 0xA818--0xA81B "BAM_P_EVNT_REG9 (at 0xF994E818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS9"
        group.long 0xA800--0xA803 "BAM_P_SW_OFSTS9 (at 0xF994E800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR9"
        group.long 0xA824--0xA827 "BAM_P_DATA_FIFO_ADDR9 (at 0xF994E824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR9"
        group.long 0xA81C--0xA81F "BAM_P_DESC_FIFO_ADDR9 (at 0xF994E81C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD9"
        group.long 0xA828--0xA82B "BAM_P_EVNT_GEN_TRSHLD9 (at 0xF994E828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES9"
        group.long 0xA820--0xA823 "BAM_P_FIFO_SIZES9 (at 0xF994E820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_9"
        group.long 0xA834--0xA837 "BAM_P_RETR_CNTXT_9 (at 0xF994E834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_9"
        group.long 0xA838--0xA83B "BAM_P_SI_CNTXT_9 (at 0xF994E838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_9"
        group.long 0xA830--0xA833 "BAM_P_DF_CNTXT_9 (at 0xF994E830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_9"
        group.long 0xA804--0xA807 "BAM_P_AU_PSM_CNTXT_1_9 (at 0xF994E804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_9"
        group.long 0xA808--0xA80B "BAM_P_PSM_CNTXT_2_9 (at 0xF994E808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_9"
        group.long 0xA80C--0xA80F "BAM_P_PSM_CNTXT_3_9 (at 0xF994E80C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_9"
        group.long 0xA810--0xA813 "BAM_P_PSM_CNTXT_4_9 (at 0xF994E810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_9"
        group.long 0xA814--0xA817 "BAM_P_PSM_CNTXT_5_9 (at 0xF994E814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 9
tree.end
tree "Pipe 10"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL10"
        group.long 0xB000--0xB003 "BAM_P_CTRL10 (at 0xF994F000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST10"
        group.long 0xB004--0xB007 "BAM_P_RST10 (at 0xF994F004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT10"
        group.long 0xB008--0xB00B "BAM_P_HALT10 (at 0xF994F008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG10"
        group.long 0xB030--0xB033 "BAM_P_TRUST_REG10 (at 0xF994F030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS10"
        group.long 0xB010--0xB013 "BAM_P_IRQ_STTS10 (at 0xF994F010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR10"
        group.long 0xB014--0xB017 "BAM_P_IRQ_CLR10 (at 0xF994F014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN10"
        group.long 0xB018--0xB01B "BAM_P_IRQ_EN10 (at 0xF994F018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER10"
        group.long 0xB01C--0xB01F "BAM_P_TIMER10 (at 0xF994F01C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL10"
        group.long 0xB020--0xB023 "BAM_P_TIMER_CTRL10 (at 0xF994F020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND10"
        group.long 0xB024--0xB027 "BAM_P_PRDCR_SDBND10 (at 0xF994F024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND10"
        group.long 0xB028--0xB02B "BAM_P_CNSMR_SDBND10 (at 0xF994F028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR10"
        group.long 0xB82C--0xB82F "BAM_P_EVNT_DEST_ADDR10 (at 0xF994F82C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG10"
        group.long 0xB818--0xB81B "BAM_P_EVNT_REG10 (at 0xF994F818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS10"
        group.long 0xB800--0xB803 "BAM_P_SW_OFSTS10 (at 0xF994F800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR10"
        group.long 0xB824--0xB827 "BAM_P_DATA_FIFO_ADDR10 (at 0xF994F824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR10"
        group.long 0xB81C--0xB81F "BAM_P_DESC_FIFO_ADDR10 (at 0xF994F81C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD10"
        group.long 0xB828--0xB82B "BAM_P_EVNT_GEN_TRSHLD10 (at 0xF994F828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES10"
        group.long 0xB820--0xB823 "BAM_P_FIFO_SIZES10 (at 0xF994F820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_10"
        group.long 0xB834--0xB837 "BAM_P_RETR_CNTXT_10 (at 0xF994F834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_10"
        group.long 0xB838--0xB83B "BAM_P_SI_CNTXT_10 (at 0xF994F838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_10"
        group.long 0xB830--0xB833 "BAM_P_DF_CNTXT_10 (at 0xF994F830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_10"
        group.long 0xB804--0xB807 "BAM_P_AU_PSM_CNTXT_1_10 (at 0xF994F804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_10"
        group.long 0xB808--0xB80B "BAM_P_PSM_CNTXT_2_10 (at 0xF994F808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_10"
        group.long 0xB80C--0xB80F "BAM_P_PSM_CNTXT_3_10 (at 0xF994F80C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_10"
        group.long 0xB810--0xB813 "BAM_P_PSM_CNTXT_4_10 (at 0xF994F810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_10"
        group.long 0xB814--0xB817 "BAM_P_PSM_CNTXT_5_10 (at 0xF994F814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 10
tree.end
tree "Pipe 11"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL11"
        group.long 0xC000--0xC003 "BAM_P_CTRL11 (at 0xF9950000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST11"
        group.long 0xC004--0xC007 "BAM_P_RST11 (at 0xF9950004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT11"
        group.long 0xC008--0xC00B "BAM_P_HALT11 (at 0xF9950008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG11"
        group.long 0xC030--0xC033 "BAM_P_TRUST_REG11 (at 0xF9950030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS11"
        group.long 0xC010--0xC013 "BAM_P_IRQ_STTS11 (at 0xF9950010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR11"
        group.long 0xC014--0xC017 "BAM_P_IRQ_CLR11 (at 0xF9950014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN11"
        group.long 0xC018--0xC01B "BAM_P_IRQ_EN11 (at 0xF9950018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER11"
        group.long 0xC01C--0xC01F "BAM_P_TIMER11 (at 0xF995001C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL11"
        group.long 0xC020--0xC023 "BAM_P_TIMER_CTRL11 (at 0xF9950020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND11"
        group.long 0xC024--0xC027 "BAM_P_PRDCR_SDBND11 (at 0xF9950024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND11"
        group.long 0xC028--0xC02B "BAM_P_CNSMR_SDBND11 (at 0xF9950028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR11"
        group.long 0xC82C--0xC82F "BAM_P_EVNT_DEST_ADDR11 (at 0xF995082C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG11"
        group.long 0xC818--0xC81B "BAM_P_EVNT_REG11 (at 0xF9950818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS11"
        group.long 0xC800--0xC803 "BAM_P_SW_OFSTS11 (at 0xF9950800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR11"
        group.long 0xC824--0xC827 "BAM_P_DATA_FIFO_ADDR11 (at 0xF9950824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR11"
        group.long 0xC81C--0xC81F "BAM_P_DESC_FIFO_ADDR11 (at 0xF995081C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD11"
        group.long 0xC828--0xC82B "BAM_P_EVNT_GEN_TRSHLD11 (at 0xF9950828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES11"
        group.long 0xC820--0xC823 "BAM_P_FIFO_SIZES11 (at 0xF9950820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_11"
        group.long 0xC834--0xC837 "BAM_P_RETR_CNTXT_11 (at 0xF9950834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_11"
        group.long 0xC838--0xC83B "BAM_P_SI_CNTXT_11 (at 0xF9950838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_11"
        group.long 0xC830--0xC833 "BAM_P_DF_CNTXT_11 (at 0xF9950830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_11"
        group.long 0xC804--0xC807 "BAM_P_AU_PSM_CNTXT_1_11 (at 0xF9950804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_11"
        group.long 0xC808--0xC80B "BAM_P_PSM_CNTXT_2_11 (at 0xF9950808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_11"
        group.long 0xC80C--0xC80F "BAM_P_PSM_CNTXT_3_11 (at 0xF995080C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_11"
        group.long 0xC810--0xC813 "BAM_P_PSM_CNTXT_4_11 (at 0xF9950810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_11"
        group.long 0xC814--0xC817 "BAM_P_PSM_CNTXT_5_11 (at 0xF9950814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 11
tree.end
tree "Pipe 12"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL12"
        group.long 0xD000--0xD003 "BAM_P_CTRL12 (at 0xF9951000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST12"
        group.long 0xD004--0xD007 "BAM_P_RST12 (at 0xF9951004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT12"
        group.long 0xD008--0xD00B "BAM_P_HALT12 (at 0xF9951008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG12"
        group.long 0xD030--0xD033 "BAM_P_TRUST_REG12 (at 0xF9951030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS12"
        group.long 0xD010--0xD013 "BAM_P_IRQ_STTS12 (at 0xF9951010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR12"
        group.long 0xD014--0xD017 "BAM_P_IRQ_CLR12 (at 0xF9951014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN12"
        group.long 0xD018--0xD01B "BAM_P_IRQ_EN12 (at 0xF9951018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER12"
        group.long 0xD01C--0xD01F "BAM_P_TIMER12 (at 0xF995101C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL12"
        group.long 0xD020--0xD023 "BAM_P_TIMER_CTRL12 (at 0xF9951020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND12"
        group.long 0xD024--0xD027 "BAM_P_PRDCR_SDBND12 (at 0xF9951024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND12"
        group.long 0xD028--0xD02B "BAM_P_CNSMR_SDBND12 (at 0xF9951028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR12"
        group.long 0xD82C--0xD82F "BAM_P_EVNT_DEST_ADDR12 (at 0xF995182C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG12"
        group.long 0xD818--0xD81B "BAM_P_EVNT_REG12 (at 0xF9951818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS12"
        group.long 0xD800--0xD803 "BAM_P_SW_OFSTS12 (at 0xF9951800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR12"
        group.long 0xD824--0xD827 "BAM_P_DATA_FIFO_ADDR12 (at 0xF9951824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR12"
        group.long 0xD81C--0xD81F "BAM_P_DESC_FIFO_ADDR12 (at 0xF995181C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD12"
        group.long 0xD828--0xD82B "BAM_P_EVNT_GEN_TRSHLD12 (at 0xF9951828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES12"
        group.long 0xD820--0xD823 "BAM_P_FIFO_SIZES12 (at 0xF9951820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_12"
        group.long 0xD834--0xD837 "BAM_P_RETR_CNTXT_12 (at 0xF9951834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_12"
        group.long 0xD838--0xD83B "BAM_P_SI_CNTXT_12 (at 0xF9951838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_12"
        group.long 0xD830--0xD833 "BAM_P_DF_CNTXT_12 (at 0xF9951830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_12"
        group.long 0xD804--0xD807 "BAM_P_AU_PSM_CNTXT_1_12 (at 0xF9951804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_12"
        group.long 0xD808--0xD80B "BAM_P_PSM_CNTXT_2_12 (at 0xF9951808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_12"
        group.long 0xD80C--0xD80F "BAM_P_PSM_CNTXT_3_12 (at 0xF995180C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_12"
        group.long 0xD810--0xD813 "BAM_P_PSM_CNTXT_4_12 (at 0xF9951810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_12"
        group.long 0xD814--0xD817 "BAM_P_PSM_CNTXT_5_12 (at 0xF9951814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 12
tree.end
tree "Pipe 13"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL13"
        group.long 0xE000--0xE003 "BAM_P_CTRL13 (at 0xF9952000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST13"
        group.long 0xE004--0xE007 "BAM_P_RST13 (at 0xF9952004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT13"
        group.long 0xE008--0xE00B "BAM_P_HALT13 (at 0xF9952008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG13"
        group.long 0xE030--0xE033 "BAM_P_TRUST_REG13 (at 0xF9952030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS13"
        group.long 0xE010--0xE013 "BAM_P_IRQ_STTS13 (at 0xF9952010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR13"
        group.long 0xE014--0xE017 "BAM_P_IRQ_CLR13 (at 0xF9952014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN13"
        group.long 0xE018--0xE01B "BAM_P_IRQ_EN13 (at 0xF9952018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER13"
        group.long 0xE01C--0xE01F "BAM_P_TIMER13 (at 0xF995201C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL13"
        group.long 0xE020--0xE023 "BAM_P_TIMER_CTRL13 (at 0xF9952020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND13"
        group.long 0xE024--0xE027 "BAM_P_PRDCR_SDBND13 (at 0xF9952024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND13"
        group.long 0xE028--0xE02B "BAM_P_CNSMR_SDBND13 (at 0xF9952028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR13"
        group.long 0xE82C--0xE82F "BAM_P_EVNT_DEST_ADDR13 (at 0xF995282C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG13"
        group.long 0xE818--0xE81B "BAM_P_EVNT_REG13 (at 0xF9952818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS13"
        group.long 0xE800--0xE803 "BAM_P_SW_OFSTS13 (at 0xF9952800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR13"
        group.long 0xE824--0xE827 "BAM_P_DATA_FIFO_ADDR13 (at 0xF9952824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR13"
        group.long 0xE81C--0xE81F "BAM_P_DESC_FIFO_ADDR13 (at 0xF995281C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD13"
        group.long 0xE828--0xE82B "BAM_P_EVNT_GEN_TRSHLD13 (at 0xF9952828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES13"
        group.long 0xE820--0xE823 "BAM_P_FIFO_SIZES13 (at 0xF9952820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_13"
        group.long 0xE834--0xE837 "BAM_P_RETR_CNTXT_13 (at 0xF9952834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_13"
        group.long 0xE838--0xE83B "BAM_P_SI_CNTXT_13 (at 0xF9952838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_13"
        group.long 0xE830--0xE833 "BAM_P_DF_CNTXT_13 (at 0xF9952830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_13"
        group.long 0xE804--0xE807 "BAM_P_AU_PSM_CNTXT_1_13 (at 0xF9952804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_13"
        group.long 0xE808--0xE80B "BAM_P_PSM_CNTXT_2_13 (at 0xF9952808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_13"
        group.long 0xE80C--0xE80F "BAM_P_PSM_CNTXT_3_13 (at 0xF995280C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_13"
        group.long 0xE810--0xE813 "BAM_P_PSM_CNTXT_4_13 (at 0xF9952810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_13"
        group.long 0xE814--0xE817 "BAM_P_PSM_CNTXT_5_13 (at 0xF9952814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 13
tree.end
tree "Pipe 14"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL14"
        group.long 0xF000--0xF003 "BAM_P_CTRL14 (at 0xF9953000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST14"
        group.long 0xF004--0xF007 "BAM_P_RST14 (at 0xF9953004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT14"
        group.long 0xF008--0xF00B "BAM_P_HALT14 (at 0xF9953008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG14"
        group.long 0xF030--0xF033 "BAM_P_TRUST_REG14 (at 0xF9953030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS14"
        group.long 0xF010--0xF013 "BAM_P_IRQ_STTS14 (at 0xF9953010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR14"
        group.long 0xF014--0xF017 "BAM_P_IRQ_CLR14 (at 0xF9953014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN14"
        group.long 0xF018--0xF01B "BAM_P_IRQ_EN14 (at 0xF9953018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER14"
        group.long 0xF01C--0xF01F "BAM_P_TIMER14 (at 0xF995301C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL14"
        group.long 0xF020--0xF023 "BAM_P_TIMER_CTRL14 (at 0xF9953020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND14"
        group.long 0xF024--0xF027 "BAM_P_PRDCR_SDBND14 (at 0xF9953024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND14"
        group.long 0xF028--0xF02B "BAM_P_CNSMR_SDBND14 (at 0xF9953028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR14"
        group.long 0xF82C--0xF82F "BAM_P_EVNT_DEST_ADDR14 (at 0xF995382C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG14"
        group.long 0xF818--0xF81B "BAM_P_EVNT_REG14 (at 0xF9953818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS14"
        group.long 0xF800--0xF803 "BAM_P_SW_OFSTS14 (at 0xF9953800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR14"
        group.long 0xF824--0xF827 "BAM_P_DATA_FIFO_ADDR14 (at 0xF9953824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR14"
        group.long 0xF81C--0xF81F "BAM_P_DESC_FIFO_ADDR14 (at 0xF995381C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD14"
        group.long 0xF828--0xF82B "BAM_P_EVNT_GEN_TRSHLD14 (at 0xF9953828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES14"
        group.long 0xF820--0xF823 "BAM_P_FIFO_SIZES14 (at 0xF9953820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_14"
        group.long 0xF834--0xF837 "BAM_P_RETR_CNTXT_14 (at 0xF9953834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_14"
        group.long 0xF838--0xF83B "BAM_P_SI_CNTXT_14 (at 0xF9953838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_14"
        group.long 0xF830--0xF833 "BAM_P_DF_CNTXT_14 (at 0xF9953830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_14"
        group.long 0xF804--0xF807 "BAM_P_AU_PSM_CNTXT_1_14 (at 0xF9953804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_14"
        group.long 0xF808--0xF80B "BAM_P_PSM_CNTXT_2_14 (at 0xF9953808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_14"
        group.long 0xF80C--0xF80F "BAM_P_PSM_CNTXT_3_14 (at 0xF995380C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_14"
        group.long 0xF810--0xF813 "BAM_P_PSM_CNTXT_4_14 (at 0xF9953810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_14"
        group.long 0xF814--0xF817 "BAM_P_PSM_CNTXT_5_14 (at 0xF9953814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 14
tree.end
tree "Pipe 15"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL15"
        group.long 0x10000--0x10003 "BAM_P_CTRL15 (at 0xF9954000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST15"
        group.long 0x10004--0x10007 "BAM_P_RST15 (at 0xF9954004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT15"
        group.long 0x10008--0x1000B "BAM_P_HALT15 (at 0xF9954008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG15"
        group.long 0x10030--0x10033 "BAM_P_TRUST_REG15 (at 0xF9954030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS15"
        group.long 0x10010--0x10013 "BAM_P_IRQ_STTS15 (at 0xF9954010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR15"
        group.long 0x10014--0x10017 "BAM_P_IRQ_CLR15 (at 0xF9954014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN15"
        group.long 0x10018--0x1001B "BAM_P_IRQ_EN15 (at 0xF9954018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER15"
        group.long 0x1001C--0x1001F "BAM_P_TIMER15 (at 0xF995401C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL15"
        group.long 0x10020--0x10023 "BAM_P_TIMER_CTRL15 (at 0xF9954020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND15"
        group.long 0x10024--0x10027 "BAM_P_PRDCR_SDBND15 (at 0xF9954024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND15"
        group.long 0x10028--0x1002B "BAM_P_CNSMR_SDBND15 (at 0xF9954028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR15"
        group.long 0x1082C--0x1082F "BAM_P_EVNT_DEST_ADDR15 (at 0xF995482C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG15"
        group.long 0x10818--0x1081B "BAM_P_EVNT_REG15 (at 0xF9954818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS15"
        group.long 0x10800--0x10803 "BAM_P_SW_OFSTS15 (at 0xF9954800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR15"
        group.long 0x10824--0x10827 "BAM_P_DATA_FIFO_ADDR15 (at 0xF9954824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR15"
        group.long 0x1081C--0x1081F "BAM_P_DESC_FIFO_ADDR15 (at 0xF995481C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD15"
        group.long 0x10828--0x1082B "BAM_P_EVNT_GEN_TRSHLD15 (at 0xF9954828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES15"
        group.long 0x10820--0x10823 "BAM_P_FIFO_SIZES15 (at 0xF9954820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_15"
        group.long 0x10834--0x10837 "BAM_P_RETR_CNTXT_15 (at 0xF9954834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_15"
        group.long 0x10838--0x1083B "BAM_P_SI_CNTXT_15 (at 0xF9954838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_15"
        group.long 0x10830--0x10833 "BAM_P_DF_CNTXT_15 (at 0xF9954830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_15"
        group.long 0x10804--0x10807 "BAM_P_AU_PSM_CNTXT_1_15 (at 0xF9954804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_15"
        group.long 0x10808--0x1080B "BAM_P_PSM_CNTXT_2_15 (at 0xF9954808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_15"
        group.long 0x1080C--0x1080F "BAM_P_PSM_CNTXT_3_15 (at 0xF995480C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_15"
        group.long 0x10810--0x10813 "BAM_P_PSM_CNTXT_4_15 (at 0xF9954810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_15"
        group.long 0x10814--0x10817 "BAM_P_PSM_CNTXT_5_15 (at 0xF9954814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 15
tree.end
tree "Pipe 16"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL16"
        group.long 0x11000--0x11003 "BAM_P_CTRL16 (at 0xF9955000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST16"
        group.long 0x11004--0x11007 "BAM_P_RST16 (at 0xF9955004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT16"
        group.long 0x11008--0x1100B "BAM_P_HALT16 (at 0xF9955008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG16"
        group.long 0x11030--0x11033 "BAM_P_TRUST_REG16 (at 0xF9955030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS16"
        group.long 0x11010--0x11013 "BAM_P_IRQ_STTS16 (at 0xF9955010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR16"
        group.long 0x11014--0x11017 "BAM_P_IRQ_CLR16 (at 0xF9955014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
