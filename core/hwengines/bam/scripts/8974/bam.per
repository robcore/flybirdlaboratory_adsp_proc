;============================================================================
;
;           M S M   R E G I S T E R  D E F I N I T I O N S
;
;                       *** AUTOGENERATED ***
;
; GENERAL DESCRIPTION
;   This file defines the MSM peripheral registers within Trace32.
;
; INITIALIZATION AND SEQUENCING REQUIREMENTS
;   Type the command "per [filename.per]" in Trace32 to view the registers.
;
;      Copyright (c) 2012  by QUALCOMM, Inc.  All Rights Reserved.
;============================================================================

config 16. 8.
width 6.
base ad:0xFD404000
tree "Crypto0"
tree "BAM Control Registers"
      tree "BAM_CTRL"
        group.long 0x0--0x3 "BAM_CTRL (at 0xFD404000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x13 " [   19]   CACHE_MISS_ERR_RESP_EN                   = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11--0x12 " [18:17]   LOCAL_CLK_GATING                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   IBC_DISABLE                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0xF " [   15]   BAM_CACHED_DESC_STORE                    = "  "0,1"
        textline ""
        bitfld.long 0x0 0xD--0xE " [14:13]   BAM_DESC_CACHE_SEL                       = "  "0,1,2,3"
        textline ""
        hexmask.long.word 0x0 0x5--0xB 1  " [11:05]   BAM_TESTBUS_SEL                          = " 
        textline ""
        bitfld.long 0x0 0x4 " [   04]   BAM_EN_ACCUM                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_EN                                   = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   BAM_SW_RST                               = "  "0,1"
        textline ""
      tree.end
      tree "BAM_REVISION"
        group.long 0x4--0x7 "BAM_REVISION (at 0xFD404004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x18--0x1F 1  " [31:24]   INACTIV_TMR_BASE                         = " 
        textline ""
        bitfld.long 0x0 0x17 " [   23]   CMD_DESC_EN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15--0x16 " [22:21]   DESC_CACHE_DEPTH                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   NUM_INACTIV_TMRS                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x13 " [   19]   INACTIV_TMRS_EXST                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x12 " [   18]   HIGH_FREQUENCY_BAM                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11 " [   17]   BAM_HAS_NO_BYPASS                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   SECURED                                  = "  "0,1"
        textline ""
        bitfld.long 0x0 0xF " [   15]   USE_VMIDMT                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0xE " [   14]   AXI_ACTIVE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0xD " [   13]   CE_BUFFER_SIZE                           = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x8--0xB 1  " [11:08]   NUM_EES                                  = " 
        textline ""
        hexmask.long.word 0x0 0x0--0x7 1  " [07:00]   REVISION                                 = " 
        textline ""
      tree.end
      tree "BAM_SW_VERSION"
        group.long 0x80--0x83 "BAM_SW_VERSION (at 0xFD404080) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x1C--0x1F 1  " [31:28]   MAJOR                                    = " 
        textline ""
        hexmask.long.word 0x0 0x10--0x1B 1  " [27:16]   MINOR                                    = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   STEP                                     = " 
        textline ""
      tree.end
      tree "BAM_NUM_PIPES"
        group.long 0x3C--0x3F "BAM_NUM_PIPES (at 0xFD40403C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x18--0x1F 1  " [31:24]   BAM_NON_PIPE_GRP                         = " 
        textline ""
        hexmask.long.word 0x0 0x10--0x17 1  " [23:16]   PERIPH_NON_PIPE_GRP                      = " 
        textline ""
        hexmask.long.word 0x0 0x0--0x7 1  " [07:00]   BAM_NUM_PIPES                            = " 
        textline ""
      tree.end
      tree "BAM_TIMER"
        group.long 0x40--0x43 "BAM_TIMER (at 0xFD404040) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   TIMER                                    = " 
        textline ""
      tree.end
      tree "BAM_TIMER_CTRL"
        group.long 0x44--0x47 "BAM_TIMER_CTRL (at 0xFD404044) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   TIMER_RST                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   TIMER_RUN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   TIMER_MODE                               = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   TIMER_TRSHLD                             = " 
        textline ""
      tree.end
      tree "BAM_DESC_CNT_TRSHLD"
        group.long 0x8--0xB "BAM_DESC_CNT_TRSHLD (at 0xFD404008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   CNT_TRSHLD                               = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS"
        group.long 0xC--0xF "BAM_IRQ_SRCS (at 0xFD40400C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK"
        group.long 0x10--0x13 "BAM_IRQ_SRCS_MSK (at 0xFD404010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED"
        group.long 0x30--0x33 "BAM_IRQ_SRCS_UNMASKED (at 0xFD404030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_STTS"
        group.long 0x14--0x17 "BAM_IRQ_STTS (at 0xFD404014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x4 " [   04]   BAM_TIMER_IRQ                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   BAM_EMPTY_IRQ                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_ERROR_IRQ                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_HRESP_ERR_IRQ                        = "  "0,1"
        textline ""
      tree.end
      tree "BAM_IRQ_CLR"
        group.long 0x18--0x1B "BAM_IRQ_CLR (at 0xFD404018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x4 " [   04]   BAM_TIMER_CLR                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   BAM_EMPTY_CLR                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_ERROR_CLR                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_HRESP_ERR_CLR                        = "  "0,1"
        textline ""
      tree.end
      tree "BAM_IRQ_EN"
        group.long 0x1C--0x1F "BAM_IRQ_EN (at 0xFD40401C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x4 " [   04]   BAM_TIMER_EN                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   BAM_EMPTY_EN                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_ERROR_EN                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_HRESP_ERR_EN                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_AHB_MASTER_ERR_CTRLS"
        group.long 0x24--0x27 "BAM_AHB_MASTER_ERR_CTRLS (at 0xFD404024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x12--0x16 1  " [22:18]   BAM_ERR_HVMID                            = " 
        textline ""
        bitfld.long 0x0 0x11 " [   17]   BAM_ERR_DIRECT_MODE                      = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0xC--0x10 1  " [16:12]   BAM_ERR_HCID                             = " 
        textline ""
        hexmask.long.word 0x0 0x8--0xB 1  " [11:08]   BAM_ERR_HPROT                            = " 
        textline ""
        bitfld.long 0x0 0x5--0x7 " [07:05]   BAM_ERR_HBURST                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x3--0x4 " [04:03]   BAM_ERR_HSIZE                            = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_ERR_HWRITE                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0--0x1 " [01:00]   BAM_ERR_HTRANS                           = "  "0,1,2,3"
        textline ""
      tree.end
      tree "BAM_AHB_MASTER_ERR_ADDR"
        group.long 0x28--0x2B "BAM_AHB_MASTER_ERR_ADDR (at 0xFD404028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   BAM_ERR_ADDR                             = " 
        textline ""
      tree.end
      tree "BAM_AHB_MASTER_ERR_DATA"
        group.long 0x2C--0x2F "BAM_AHB_MASTER_ERR_DATA (at 0xFD40402C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   BAM_ERR_DATA                             = " 
        textline ""
      tree.end
      tree "BAM_TRUST_REG"
        group.long 0x70--0x73 "BAM_TRUST_REG (at 0xFD404070) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0xD " [   13]   LOCK_EE_CTRL                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_VMID                                 = " 
        textline ""
        bitfld.long 0x0 0x7 " [   07]   BAM_RST_BLOCK                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_EE                                   = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_TEST_BUS_SEL"
        group.long 0x74--0x77 "BAM_TEST_BUS_SEL (at 0xFD404074) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x15 " [   21]   SW_EVENTS_ZERO                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x13--0x14 " [20:19]   SW_EVENTS_SEL                            = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x12 " [   18]   BAM_DATA_ERASE                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11 " [   17]   BAM_DATA_FLUSH                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   BAM_CLK_ALWAYS_ON                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x0--0x6 1  " [06:00]   BAM_TESTBUS_SEL                          = " 
        textline ""
      tree.end
      tree "BAM_TEST_BUS_REG"
        group.long 0x78--0x7B "BAM_TEST_BUS_REG (at 0xFD404078) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   BAM_TESTBUS_REG                          = " 
        textline ""
      tree.end
      tree "BAM_CNFG_BITS"
        group.long 0x7C--0x7F "BAM_CNFG_BITS (at 0xFD40407C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1E " [   30]   MULTIPLE_EVENTS_DESC_AVAIL_EN            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   MULTIPLE_EVENTS_SIZE_EN                  = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1C " [   28]   BAM_ZLT_W_CD_SUPPORT                     = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1B " [   27]   BAM_CD_ENABLE                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1A " [   26]   BAM_AU_ACCUMED                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x19 " [   25]   BAM_PSM_P_HD_DATA                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_REG_P_EN                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_WB_DSC_AVL_P_RST                     = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_WB_RETR_SVPNT                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_WB_CSW_ACK_IDL                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_WB_BLK_CSW                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x13 " [   19]   BAM_WB_P_RES                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x12 " [   18]   BAM_SI_P_RES                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11 " [   17]   BAM_AU_P_RES                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   BAM_PSM_P_RES                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0xF " [   15]   BAM_PSM_CSW_REQ                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0xE " [   14]   BAM_SB_CLK_REQ                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0xD " [   13]   BAM_IBC_DISABLE                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0xC " [   12]   BAM_NO_EXT_P_RST                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0xB " [   11]   BAM_FULL_PIPE                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   BAM_ADML_SYNC_BRIDGE                     = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_PIPE_CNFG                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_ADML_DEEP_CONS_FIFO                  = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   BAM_ADML_INCR4_EN_N                      = "  "0,1"
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE0"
        group.long 0x800--0x803 "BAM_IRQ_SRCS_EE0 (at 0xFD404800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE1"
        group.long 0x880--0x883 "BAM_IRQ_SRCS_EE1 (at 0xFD404880) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE2"
        group.long 0x900--0x903 "BAM_IRQ_SRCS_EE2 (at 0xFD404900) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE3"
        group.long 0x980--0x983 "BAM_IRQ_SRCS_EE3 (at 0xFD404980) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE4"
        group.long 0xA00--0xA03 "BAM_IRQ_SRCS_EE4 (at 0xFD404A00) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE5"
        group.long 0xA80--0xA83 "BAM_IRQ_SRCS_EE5 (at 0xFD404A80) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE6"
        group.long 0xB00--0xB03 "BAM_IRQ_SRCS_EE6 (at 0xFD404B00) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE7"
        group.long 0xB80--0xB83 "BAM_IRQ_SRCS_EE7 (at 0xFD404B80) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE0"
        group.long 0x804--0x807 "BAM_IRQ_SRCS_MSK_EE0 (at 0xFD404804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE1"
        group.long 0x884--0x887 "BAM_IRQ_SRCS_MSK_EE1 (at 0xFD404884) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE2"
        group.long 0x904--0x907 "BAM_IRQ_SRCS_MSK_EE2 (at 0xFD404904) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE3"
        group.long 0x984--0x987 "BAM_IRQ_SRCS_MSK_EE3 (at 0xFD404984) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE4"
        group.long 0xA04--0xA07 "BAM_IRQ_SRCS_MSK_EE4 (at 0xFD404A04) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE5"
        group.long 0xA84--0xA87 "BAM_IRQ_SRCS_MSK_EE5 (at 0xFD404A84) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE6"
        group.long 0xB04--0xB07 "BAM_IRQ_SRCS_MSK_EE6 (at 0xFD404B04) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE7"
        group.long 0xB84--0xB87 "BAM_IRQ_SRCS_MSK_EE7 (at 0xFD404B84) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE0"
        group.long 0x808--0x80B "BAM_IRQ_SRCS_UNMASKED_EE0 (at 0xFD404808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE1"
        group.long 0x888--0x88B "BAM_IRQ_SRCS_UNMASKED_EE1 (at 0xFD404888) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE2"
        group.long 0x908--0x90B "BAM_IRQ_SRCS_UNMASKED_EE2 (at 0xFD404908) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE3"
        group.long 0x988--0x98B "BAM_IRQ_SRCS_UNMASKED_EE3 (at 0xFD404988) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE4"
        group.long 0xA08--0xA0B "BAM_IRQ_SRCS_UNMASKED_EE4 (at 0xFD404A08) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE5"
        group.long 0xA88--0xA8B "BAM_IRQ_SRCS_UNMASKED_EE5 (at 0xFD404A88) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE6"
        group.long 0xB08--0xB0B "BAM_IRQ_SRCS_UNMASKED_EE6 (at 0xFD404B08) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE7"
        group.long 0xB88--0xB8B "BAM_IRQ_SRCS_UNMASKED_EE7 (at 0xFD404B88) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
;End of BAM Control Registers
tree.end
tree "Pipe 0"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL0"
        group.long 0x1000--0x1003 "BAM_P_CTRL0 (at 0xFD405000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST0"
        group.long 0x1004--0x1007 "BAM_P_RST0 (at 0xFD405004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT0"
        group.long 0x1008--0x100B "BAM_P_HALT0 (at 0xFD405008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG0"
        group.long 0x1030--0x1033 "BAM_P_TRUST_REG0 (at 0xFD405030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS0"
        group.long 0x1010--0x1013 "BAM_P_IRQ_STTS0 (at 0xFD405010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR0"
        group.long 0x1014--0x1017 "BAM_P_IRQ_CLR0 (at 0xFD405014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN0"
        group.long 0x1018--0x101B "BAM_P_IRQ_EN0 (at 0xFD405018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER0"
        group.long 0x101C--0x101F "BAM_P_TIMER0 (at 0xFD40501C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL0"
        group.long 0x1020--0x1023 "BAM_P_TIMER_CTRL0 (at 0xFD405020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND0"
        group.long 0x1024--0x1027 "BAM_P_PRDCR_SDBND0 (at 0xFD405024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND0"
        group.long 0x1028--0x102B "BAM_P_CNSMR_SDBND0 (at 0xFD405028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR0"
        group.long 0x182C--0x182F "BAM_P_EVNT_DEST_ADDR0 (at 0xFD40582C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG0"
        group.long 0x1818--0x181B "BAM_P_EVNT_REG0 (at 0xFD405818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS0"
        group.long 0x1800--0x1803 "BAM_P_SW_OFSTS0 (at 0xFD405800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR0"
        group.long 0x1824--0x1827 "BAM_P_DATA_FIFO_ADDR0 (at 0xFD405824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR0"
        group.long 0x181C--0x181F "BAM_P_DESC_FIFO_ADDR0 (at 0xFD40581C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD0"
        group.long 0x1828--0x182B "BAM_P_EVNT_GEN_TRSHLD0 (at 0xFD405828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES0"
        group.long 0x1820--0x1823 "BAM_P_FIFO_SIZES0 (at 0xFD405820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_0"
        group.long 0x1834--0x1837 "BAM_P_RETR_CNTXT_0 (at 0xFD405834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_0"
        group.long 0x1838--0x183B "BAM_P_SI_CNTXT_0 (at 0xFD405838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_0"
        group.long 0x1830--0x1833 "BAM_P_DF_CNTXT_0 (at 0xFD405830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_0"
        group.long 0x1804--0x1807 "BAM_P_AU_PSM_CNTXT_1_0 (at 0xFD405804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_0"
        group.long 0x1808--0x180B "BAM_P_PSM_CNTXT_2_0 (at 0xFD405808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_0"
        group.long 0x180C--0x180F "BAM_P_PSM_CNTXT_3_0 (at 0xFD40580C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_0"
        group.long 0x1810--0x1813 "BAM_P_PSM_CNTXT_4_0 (at 0xFD405810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_0"
        group.long 0x1814--0x1817 "BAM_P_PSM_CNTXT_5_0 (at 0xFD405814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 0
tree.end
tree "Pipe 1"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL1"
        group.long 0x2000--0x2003 "BAM_P_CTRL1 (at 0xFD406000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST1"
        group.long 0x2004--0x2007 "BAM_P_RST1 (at 0xFD406004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT1"
        group.long 0x2008--0x200B "BAM_P_HALT1 (at 0xFD406008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG1"
        group.long 0x2030--0x2033 "BAM_P_TRUST_REG1 (at 0xFD406030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS1"
        group.long 0x2010--0x2013 "BAM_P_IRQ_STTS1 (at 0xFD406010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR1"
        group.long 0x2014--0x2017 "BAM_P_IRQ_CLR1 (at 0xFD406014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN1"
        group.long 0x2018--0x201B "BAM_P_IRQ_EN1 (at 0xFD406018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER1"
        group.long 0x201C--0x201F "BAM_P_TIMER1 (at 0xFD40601C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL1"
        group.long 0x2020--0x2023 "BAM_P_TIMER_CTRL1 (at 0xFD406020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND1"
        group.long 0x2024--0x2027 "BAM_P_PRDCR_SDBND1 (at 0xFD406024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND1"
        group.long 0x2028--0x202B "BAM_P_CNSMR_SDBND1 (at 0xFD406028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR1"
        group.long 0x282C--0x282F "BAM_P_EVNT_DEST_ADDR1 (at 0xFD40682C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG1"
        group.long 0x2818--0x281B "BAM_P_EVNT_REG1 (at 0xFD406818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS1"
        group.long 0x2800--0x2803 "BAM_P_SW_OFSTS1 (at 0xFD406800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR1"
        group.long 0x2824--0x2827 "BAM_P_DATA_FIFO_ADDR1 (at 0xFD406824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR1"
        group.long 0x281C--0x281F "BAM_P_DESC_FIFO_ADDR1 (at 0xFD40681C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD1"
        group.long 0x2828--0x282B "BAM_P_EVNT_GEN_TRSHLD1 (at 0xFD406828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES1"
        group.long 0x2820--0x2823 "BAM_P_FIFO_SIZES1 (at 0xFD406820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_1"
        group.long 0x2834--0x2837 "BAM_P_RETR_CNTXT_1 (at 0xFD406834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_1"
        group.long 0x2838--0x283B "BAM_P_SI_CNTXT_1 (at 0xFD406838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_1"
        group.long 0x2830--0x2833 "BAM_P_DF_CNTXT_1 (at 0xFD406830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_1"
        group.long 0x2804--0x2807 "BAM_P_AU_PSM_CNTXT_1_1 (at 0xFD406804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_1"
        group.long 0x2808--0x280B "BAM_P_PSM_CNTXT_2_1 (at 0xFD406808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_1"
        group.long 0x280C--0x280F "BAM_P_PSM_CNTXT_3_1 (at 0xFD40680C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_1"
        group.long 0x2810--0x2813 "BAM_P_PSM_CNTXT_4_1 (at 0xFD406810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_1"
        group.long 0x2814--0x2817 "BAM_P_PSM_CNTXT_5_1 (at 0xFD406814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 1
tree.end
tree "Pipe 2"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL2"
        group.long 0x3000--0x3003 "BAM_P_CTRL2 (at 0xFD407000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST2"
        group.long 0x3004--0x3007 "BAM_P_RST2 (at 0xFD407004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT2"
        group.long 0x3008--0x300B "BAM_P_HALT2 (at 0xFD407008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG2"
        group.long 0x3030--0x3033 "BAM_P_TRUST_REG2 (at 0xFD407030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS2"
        group.long 0x3010--0x3013 "BAM_P_IRQ_STTS2 (at 0xFD407010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR2"
        group.long 0x3014--0x3017 "BAM_P_IRQ_CLR2 (at 0xFD407014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN2"
        group.long 0x3018--0x301B "BAM_P_IRQ_EN2 (at 0xFD407018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER2"
        group.long 0x301C--0x301F "BAM_P_TIMER2 (at 0xFD40701C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL2"
        group.long 0x3020--0x3023 "BAM_P_TIMER_CTRL2 (at 0xFD407020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND2"
        group.long 0x3024--0x3027 "BAM_P_PRDCR_SDBND2 (at 0xFD407024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND2"
        group.long 0x3028--0x302B "BAM_P_CNSMR_SDBND2 (at 0xFD407028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR2"
        group.long 0x382C--0x382F "BAM_P_EVNT_DEST_ADDR2 (at 0xFD40782C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG2"
        group.long 0x3818--0x381B "BAM_P_EVNT_REG2 (at 0xFD407818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS2"
        group.long 0x3800--0x3803 "BAM_P_SW_OFSTS2 (at 0xFD407800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR2"
        group.long 0x3824--0x3827 "BAM_P_DATA_FIFO_ADDR2 (at 0xFD407824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR2"
        group.long 0x381C--0x381F "BAM_P_DESC_FIFO_ADDR2 (at 0xFD40781C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD2"
        group.long 0x3828--0x382B "BAM_P_EVNT_GEN_TRSHLD2 (at 0xFD407828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES2"
        group.long 0x3820--0x3823 "BAM_P_FIFO_SIZES2 (at 0xFD407820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_2"
        group.long 0x3834--0x3837 "BAM_P_RETR_CNTXT_2 (at 0xFD407834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_2"
        group.long 0x3838--0x383B "BAM_P_SI_CNTXT_2 (at 0xFD407838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_2"
        group.long 0x3830--0x3833 "BAM_P_DF_CNTXT_2 (at 0xFD407830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_2"
        group.long 0x3804--0x3807 "BAM_P_AU_PSM_CNTXT_1_2 (at 0xFD407804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_2"
        group.long 0x3808--0x380B "BAM_P_PSM_CNTXT_2_2 (at 0xFD407808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_2"
        group.long 0x380C--0x380F "BAM_P_PSM_CNTXT_3_2 (at 0xFD40780C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_2"
        group.long 0x3810--0x3813 "BAM_P_PSM_CNTXT_4_2 (at 0xFD407810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_2"
        group.long 0x3814--0x3817 "BAM_P_PSM_CNTXT_5_2 (at 0xFD407814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 2
tree.end
tree "Pipe 3"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL3"
        group.long 0x4000--0x4003 "BAM_P_CTRL3 (at 0xFD408000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST3"
        group.long 0x4004--0x4007 "BAM_P_RST3 (at 0xFD408004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT3"
        group.long 0x4008--0x400B "BAM_P_HALT3 (at 0xFD408008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG3"
        group.long 0x4030--0x4033 "BAM_P_TRUST_REG3 (at 0xFD408030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS3"
        group.long 0x4010--0x4013 "BAM_P_IRQ_STTS3 (at 0xFD408010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR3"
        group.long 0x4014--0x4017 "BAM_P_IRQ_CLR3 (at 0xFD408014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN3"
        group.long 0x4018--0x401B "BAM_P_IRQ_EN3 (at 0xFD408018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER3"
        group.long 0x401C--0x401F "BAM_P_TIMER3 (at 0xFD40801C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL3"
        group.long 0x4020--0x4023 "BAM_P_TIMER_CTRL3 (at 0xFD408020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND3"
        group.long 0x4024--0x4027 "BAM_P_PRDCR_SDBND3 (at 0xFD408024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND3"
        group.long 0x4028--0x402B "BAM_P_CNSMR_SDBND3 (at 0xFD408028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR3"
        group.long 0x482C--0x482F "BAM_P_EVNT_DEST_ADDR3 (at 0xFD40882C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG3"
        group.long 0x4818--0x481B "BAM_P_EVNT_REG3 (at 0xFD408818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS3"
        group.long 0x4800--0x4803 "BAM_P_SW_OFSTS3 (at 0xFD408800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR3"
        group.long 0x4824--0x4827 "BAM_P_DATA_FIFO_ADDR3 (at 0xFD408824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR3"
        group.long 0x481C--0x481F "BAM_P_DESC_FIFO_ADDR3 (at 0xFD40881C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD3"
        group.long 0x4828--0x482B "BAM_P_EVNT_GEN_TRSHLD3 (at 0xFD408828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES3"
        group.long 0x4820--0x4823 "BAM_P_FIFO_SIZES3 (at 0xFD408820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_3"
        group.long 0x4834--0x4837 "BAM_P_RETR_CNTXT_3 (at 0xFD408834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_3"
        group.long 0x4838--0x483B "BAM_P_SI_CNTXT_3 (at 0xFD408838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_3"
        group.long 0x4830--0x4833 "BAM_P_DF_CNTXT_3 (at 0xFD408830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_3"
        group.long 0x4804--0x4807 "BAM_P_AU_PSM_CNTXT_1_3 (at 0xFD408804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_3"
        group.long 0x4808--0x480B "BAM_P_PSM_CNTXT_2_3 (at 0xFD408808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_3"
        group.long 0x480C--0x480F "BAM_P_PSM_CNTXT_3_3 (at 0xFD40880C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_3"
        group.long 0x4810--0x4813 "BAM_P_PSM_CNTXT_4_3 (at 0xFD408810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_3"
        group.long 0x4814--0x4817 "BAM_P_PSM_CNTXT_5_3 (at 0xFD408814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 3
tree.end
tree "Pipe 4"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL4"
        group.long 0x5000--0x5003 "BAM_P_CTRL4 (at 0xFD409000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST4"
        group.long 0x5004--0x5007 "BAM_P_RST4 (at 0xFD409004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT4"
        group.long 0x5008--0x500B "BAM_P_HALT4 (at 0xFD409008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG4"
        group.long 0x5030--0x5033 "BAM_P_TRUST_REG4 (at 0xFD409030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS4"
        group.long 0x5010--0x5013 "BAM_P_IRQ_STTS4 (at 0xFD409010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR4"
        group.long 0x5014--0x5017 "BAM_P_IRQ_CLR4 (at 0xFD409014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN4"
        group.long 0x5018--0x501B "BAM_P_IRQ_EN4 (at 0xFD409018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER4"
        group.long 0x501C--0x501F "BAM_P_TIMER4 (at 0xFD40901C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL4"
        group.long 0x5020--0x5023 "BAM_P_TIMER_CTRL4 (at 0xFD409020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND4"
        group.long 0x5024--0x5027 "BAM_P_PRDCR_SDBND4 (at 0xFD409024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND4"
        group.long 0x5028--0x502B "BAM_P_CNSMR_SDBND4 (at 0xFD409028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR4"
        group.long 0x582C--0x582F "BAM_P_EVNT_DEST_ADDR4 (at 0xFD40982C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG4"
        group.long 0x5818--0x581B "BAM_P_EVNT_REG4 (at 0xFD409818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS4"
        group.long 0x5800--0x5803 "BAM_P_SW_OFSTS4 (at 0xFD409800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR4"
        group.long 0x5824--0x5827 "BAM_P_DATA_FIFO_ADDR4 (at 0xFD409824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR4"
        group.long 0x581C--0x581F "BAM_P_DESC_FIFO_ADDR4 (at 0xFD40981C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD4"
        group.long 0x5828--0x582B "BAM_P_EVNT_GEN_TRSHLD4 (at 0xFD409828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES4"
        group.long 0x5820--0x5823 "BAM_P_FIFO_SIZES4 (at 0xFD409820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_4"
        group.long 0x5834--0x5837 "BAM_P_RETR_CNTXT_4 (at 0xFD409834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_4"
        group.long 0x5838--0x583B "BAM_P_SI_CNTXT_4 (at 0xFD409838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_4"
        group.long 0x5830--0x5833 "BAM_P_DF_CNTXT_4 (at 0xFD409830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_4"
        group.long 0x5804--0x5807 "BAM_P_AU_PSM_CNTXT_1_4 (at 0xFD409804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_4"
        group.long 0x5808--0x580B "BAM_P_PSM_CNTXT_2_4 (at 0xFD409808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_4"
        group.long 0x580C--0x580F "BAM_P_PSM_CNTXT_3_4 (at 0xFD40980C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_4"
        group.long 0x5810--0x5813 "BAM_P_PSM_CNTXT_4_4 (at 0xFD409810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_4"
        group.long 0x5814--0x5817 "BAM_P_PSM_CNTXT_5_4 (at 0xFD409814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 4
tree.end
tree "Pipe 5"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL5"
        group.long 0x6000--0x6003 "BAM_P_CTRL5 (at 0xFD40A000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST5"
        group.long 0x6004--0x6007 "BAM_P_RST5 (at 0xFD40A004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT5"
        group.long 0x6008--0x600B "BAM_P_HALT5 (at 0xFD40A008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG5"
        group.long 0x6030--0x6033 "BAM_P_TRUST_REG5 (at 0xFD40A030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS5"
        group.long 0x6010--0x6013 "BAM_P_IRQ_STTS5 (at 0xFD40A010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR5"
        group.long 0x6014--0x6017 "BAM_P_IRQ_CLR5 (at 0xFD40A014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN5"
        group.long 0x6018--0x601B "BAM_P_IRQ_EN5 (at 0xFD40A018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER5"
        group.long 0x601C--0x601F "BAM_P_TIMER5 (at 0xFD40A01C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL5"
        group.long 0x6020--0x6023 "BAM_P_TIMER_CTRL5 (at 0xFD40A020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND5"
        group.long 0x6024--0x6027 "BAM_P_PRDCR_SDBND5 (at 0xFD40A024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND5"
        group.long 0x6028--0x602B "BAM_P_CNSMR_SDBND5 (at 0xFD40A028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR5"
        group.long 0x682C--0x682F "BAM_P_EVNT_DEST_ADDR5 (at 0xFD40A82C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG5"
        group.long 0x6818--0x681B "BAM_P_EVNT_REG5 (at 0xFD40A818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS5"
        group.long 0x6800--0x6803 "BAM_P_SW_OFSTS5 (at 0xFD40A800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR5"
        group.long 0x6824--0x6827 "BAM_P_DATA_FIFO_ADDR5 (at 0xFD40A824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR5"
        group.long 0x681C--0x681F "BAM_P_DESC_FIFO_ADDR5 (at 0xFD40A81C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD5"
        group.long 0x6828--0x682B "BAM_P_EVNT_GEN_TRSHLD5 (at 0xFD40A828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES5"
        group.long 0x6820--0x6823 "BAM_P_FIFO_SIZES5 (at 0xFD40A820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_5"
        group.long 0x6834--0x6837 "BAM_P_RETR_CNTXT_5 (at 0xFD40A834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_5"
        group.long 0x6838--0x683B "BAM_P_SI_CNTXT_5 (at 0xFD40A838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_5"
        group.long 0x6830--0x6833 "BAM_P_DF_CNTXT_5 (at 0xFD40A830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_5"
        group.long 0x6804--0x6807 "BAM_P_AU_PSM_CNTXT_1_5 (at 0xFD40A804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_5"
        group.long 0x6808--0x680B "BAM_P_PSM_CNTXT_2_5 (at 0xFD40A808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_5"
        group.long 0x680C--0x680F "BAM_P_PSM_CNTXT_3_5 (at 0xFD40A80C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_5"
        group.long 0x6810--0x6813 "BAM_P_PSM_CNTXT_4_5 (at 0xFD40A810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_5"
        group.long 0x6814--0x6817 "BAM_P_PSM_CNTXT_5_5 (at 0xFD40A814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 5
tree.end
tree "Pipe 6"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL6"
        group.long 0x7000--0x7003 "BAM_P_CTRL6 (at 0xFD40B000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST6"
        group.long 0x7004--0x7007 "BAM_P_RST6 (at 0xFD40B004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT6"
        group.long 0x7008--0x700B "BAM_P_HALT6 (at 0xFD40B008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG6"
        group.long 0x7030--0x7033 "BAM_P_TRUST_REG6 (at 0xFD40B030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS6"
        group.long 0x7010--0x7013 "BAM_P_IRQ_STTS6 (at 0xFD40B010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR6"
        group.long 0x7014--0x7017 "BAM_P_IRQ_CLR6 (at 0xFD40B014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN6"
        group.long 0x7018--0x701B "BAM_P_IRQ_EN6 (at 0xFD40B018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER6"
        group.long 0x701C--0x701F "BAM_P_TIMER6 (at 0xFD40B01C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL6"
        group.long 0x7020--0x7023 "BAM_P_TIMER_CTRL6 (at 0xFD40B020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND6"
        group.long 0x7024--0x7027 "BAM_P_PRDCR_SDBND6 (at 0xFD40B024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND6"
        group.long 0x7028--0x702B "BAM_P_CNSMR_SDBND6 (at 0xFD40B028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR6"
        group.long 0x782C--0x782F "BAM_P_EVNT_DEST_ADDR6 (at 0xFD40B82C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG6"
        group.long 0x7818--0x781B "BAM_P_EVNT_REG6 (at 0xFD40B818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS6"
        group.long 0x7800--0x7803 "BAM_P_SW_OFSTS6 (at 0xFD40B800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR6"
        group.long 0x7824--0x7827 "BAM_P_DATA_FIFO_ADDR6 (at 0xFD40B824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR6"
        group.long 0x781C--0x781F "BAM_P_DESC_FIFO_ADDR6 (at 0xFD40B81C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD6"
        group.long 0x7828--0x782B "BAM_P_EVNT_GEN_TRSHLD6 (at 0xFD40B828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES6"
        group.long 0x7820--0x7823 "BAM_P_FIFO_SIZES6 (at 0xFD40B820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_6"
        group.long 0x7834--0x7837 "BAM_P_RETR_CNTXT_6 (at 0xFD40B834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_6"
        group.long 0x7838--0x783B "BAM_P_SI_CNTXT_6 (at 0xFD40B838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_6"
        group.long 0x7830--0x7833 "BAM_P_DF_CNTXT_6 (at 0xFD40B830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_6"
        group.long 0x7804--0x7807 "BAM_P_AU_PSM_CNTXT_1_6 (at 0xFD40B804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_6"
        group.long 0x7808--0x780B "BAM_P_PSM_CNTXT_2_6 (at 0xFD40B808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_6"
        group.long 0x780C--0x780F "BAM_P_PSM_CNTXT_3_6 (at 0xFD40B80C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_6"
        group.long 0x7810--0x7813 "BAM_P_PSM_CNTXT_4_6 (at 0xFD40B810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_6"
        group.long 0x7814--0x7817 "BAM_P_PSM_CNTXT_5_6 (at 0xFD40B814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 6
tree.end
tree "Pipe 7"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL7"
        group.long 0x8000--0x8003 "BAM_P_CTRL7 (at 0xFD40C000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST7"
        group.long 0x8004--0x8007 "BAM_P_RST7 (at 0xFD40C004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT7"
        group.long 0x8008--0x800B "BAM_P_HALT7 (at 0xFD40C008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG7"
        group.long 0x8030--0x8033 "BAM_P_TRUST_REG7 (at 0xFD40C030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS7"
        group.long 0x8010--0x8013 "BAM_P_IRQ_STTS7 (at 0xFD40C010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR7"
        group.long 0x8014--0x8017 "BAM_P_IRQ_CLR7 (at 0xFD40C014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN7"
        group.long 0x8018--0x801B "BAM_P_IRQ_EN7 (at 0xFD40C018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER7"
        group.long 0x801C--0x801F "BAM_P_TIMER7 (at 0xFD40C01C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL7"
        group.long 0x8020--0x8023 "BAM_P_TIMER_CTRL7 (at 0xFD40C020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND7"
        group.long 0x8024--0x8027 "BAM_P_PRDCR_SDBND7 (at 0xFD40C024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND7"
        group.long 0x8028--0x802B "BAM_P_CNSMR_SDBND7 (at 0xFD40C028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR7"
        group.long 0x882C--0x882F "BAM_P_EVNT_DEST_ADDR7 (at 0xFD40C82C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG7"
        group.long 0x8818--0x881B "BAM_P_EVNT_REG7 (at 0xFD40C818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS7"
        group.long 0x8800--0x8803 "BAM_P_SW_OFSTS7 (at 0xFD40C800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR7"
        group.long 0x8824--0x8827 "BAM_P_DATA_FIFO_ADDR7 (at 0xFD40C824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR7"
        group.long 0x881C--0x881F "BAM_P_DESC_FIFO_ADDR7 (at 0xFD40C81C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD7"
        group.long 0x8828--0x882B "BAM_P_EVNT_GEN_TRSHLD7 (at 0xFD40C828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES7"
        group.long 0x8820--0x8823 "BAM_P_FIFO_SIZES7 (at 0xFD40C820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_7"
        group.long 0x8834--0x8837 "BAM_P_RETR_CNTXT_7 (at 0xFD40C834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_7"
        group.long 0x8838--0x883B "BAM_P_SI_CNTXT_7 (at 0xFD40C838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_7"
        group.long 0x8830--0x8833 "BAM_P_DF_CNTXT_7 (at 0xFD40C830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_7"
        group.long 0x8804--0x8807 "BAM_P_AU_PSM_CNTXT_1_7 (at 0xFD40C804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_7"
        group.long 0x8808--0x880B "BAM_P_PSM_CNTXT_2_7 (at 0xFD40C808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_7"
        group.long 0x880C--0x880F "BAM_P_PSM_CNTXT_3_7 (at 0xFD40C80C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_7"
        group.long 0x8810--0x8813 "BAM_P_PSM_CNTXT_4_7 (at 0xFD40C810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_7"
        group.long 0x8814--0x8817 "BAM_P_PSM_CNTXT_5_7 (at 0xFD40C814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 7
tree.end
tree.end
;Block Per Data Ends

base ad:0xFD444000
tree "Crypto1"
tree "BAM Control Registers"
      tree "BAM_CTRL"
        group.long 0x0--0x3 "BAM_CTRL (at 0xFD444000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x13 " [   19]   CACHE_MISS_ERR_RESP_EN                   = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11--0x12 " [18:17]   LOCAL_CLK_GATING                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   IBC_DISABLE                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0xF " [   15]   BAM_CACHED_DESC_STORE                    = "  "0,1"
        textline ""
        bitfld.long 0x0 0xD--0xE " [14:13]   BAM_DESC_CACHE_SEL                       = "  "0,1,2,3"
        textline ""
        hexmask.long.word 0x0 0x5--0xB 1  " [11:05]   BAM_TESTBUS_SEL                          = " 
        textline ""
        bitfld.long 0x0 0x4 " [   04]   BAM_EN_ACCUM                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_EN                                   = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   BAM_SW_RST                               = "  "0,1"
        textline ""
      tree.end
      tree "BAM_REVISION"
        group.long 0x4--0x7 "BAM_REVISION (at 0xFD444004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x18--0x1F 1  " [31:24]   INACTIV_TMR_BASE                         = " 
        textline ""
        bitfld.long 0x0 0x17 " [   23]   CMD_DESC_EN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15--0x16 " [22:21]   DESC_CACHE_DEPTH                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   NUM_INACTIV_TMRS                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x13 " [   19]   INACTIV_TMRS_EXST                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x12 " [   18]   HIGH_FREQUENCY_BAM                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11 " [   17]   BAM_HAS_NO_BYPASS                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   SECURED                                  = "  "0,1"
        textline ""
        bitfld.long 0x0 0xF " [   15]   USE_VMIDMT                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0xE " [   14]   AXI_ACTIVE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0xD " [   13]   CE_BUFFER_SIZE                           = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x8--0xB 1  " [11:08]   NUM_EES                                  = " 
        textline ""
        hexmask.long.word 0x0 0x0--0x7 1  " [07:00]   REVISION                                 = " 
        textline ""
      tree.end
      tree "BAM_SW_VERSION"
        group.long 0x80--0x83 "BAM_SW_VERSION (at 0xFD444080) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x1C--0x1F 1  " [31:28]   MAJOR                                    = " 
        textline ""
        hexmask.long.word 0x0 0x10--0x1B 1  " [27:16]   MINOR                                    = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   STEP                                     = " 
        textline ""
      tree.end
      tree "BAM_NUM_PIPES"
        group.long 0x3C--0x3F "BAM_NUM_PIPES (at 0xFD44403C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x18--0x1F 1  " [31:24]   BAM_NON_PIPE_GRP                         = " 
        textline ""
        hexmask.long.word 0x0 0x10--0x17 1  " [23:16]   PERIPH_NON_PIPE_GRP                      = " 
        textline ""
        hexmask.long.word 0x0 0x0--0x7 1  " [07:00]   BAM_NUM_PIPES                            = " 
        textline ""
      tree.end
      tree "BAM_TIMER"
        group.long 0x40--0x43 "BAM_TIMER (at 0xFD444040) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   TIMER                                    = " 
        textline ""
      tree.end
      tree "BAM_TIMER_CTRL"
        group.long 0x44--0x47 "BAM_TIMER_CTRL (at 0xFD444044) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   TIMER_RST                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   TIMER_RUN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   TIMER_MODE                               = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   TIMER_TRSHLD                             = " 
        textline ""
      tree.end
      tree "BAM_DESC_CNT_TRSHLD"
        group.long 0x8--0xB "BAM_DESC_CNT_TRSHLD (at 0xFD444008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   CNT_TRSHLD                               = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS"
        group.long 0xC--0xF "BAM_IRQ_SRCS (at 0xFD44400C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK"
        group.long 0x10--0x13 "BAM_IRQ_SRCS_MSK (at 0xFD444010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED"
        group.long 0x30--0x33 "BAM_IRQ_SRCS_UNMASKED (at 0xFD444030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_STTS"
        group.long 0x14--0x17 "BAM_IRQ_STTS (at 0xFD444014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x4 " [   04]   BAM_TIMER_IRQ                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   BAM_EMPTY_IRQ                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_ERROR_IRQ                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_HRESP_ERR_IRQ                        = "  "0,1"
        textline ""
      tree.end
      tree "BAM_IRQ_CLR"
        group.long 0x18--0x1B "BAM_IRQ_CLR (at 0xFD444018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x4 " [   04]   BAM_TIMER_CLR                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   BAM_EMPTY_CLR                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_ERROR_CLR                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_HRESP_ERR_CLR                        = "  "0,1"
        textline ""
      tree.end
      tree "BAM_IRQ_EN"
        group.long 0x1C--0x1F "BAM_IRQ_EN (at 0xFD44401C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x4 " [   04]   BAM_TIMER_EN                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   BAM_EMPTY_EN                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_ERROR_EN                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_HRESP_ERR_EN                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_AHB_MASTER_ERR_CTRLS"
        group.long 0x24--0x27 "BAM_AHB_MASTER_ERR_CTRLS (at 0xFD444024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x12--0x16 1  " [22:18]   BAM_ERR_HVMID                            = " 
        textline ""
        bitfld.long 0x0 0x11 " [   17]   BAM_ERR_DIRECT_MODE                      = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0xC--0x10 1  " [16:12]   BAM_ERR_HCID                             = " 
        textline ""
        hexmask.long.word 0x0 0x8--0xB 1  " [11:08]   BAM_ERR_HPROT                            = " 
        textline ""
        bitfld.long 0x0 0x5--0x7 " [07:05]   BAM_ERR_HBURST                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x3--0x4 " [04:03]   BAM_ERR_HSIZE                            = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_ERR_HWRITE                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0--0x1 " [01:00]   BAM_ERR_HTRANS                           = "  "0,1,2,3"
        textline ""
      tree.end
      tree "BAM_AHB_MASTER_ERR_ADDR"
        group.long 0x28--0x2B "BAM_AHB_MASTER_ERR_ADDR (at 0xFD444028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   BAM_ERR_ADDR                             = " 
        textline ""
      tree.end
      tree "BAM_AHB_MASTER_ERR_DATA"
        group.long 0x2C--0x2F "BAM_AHB_MASTER_ERR_DATA (at 0xFD44402C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   BAM_ERR_DATA                             = " 
        textline ""
      tree.end
      tree "BAM_TRUST_REG"
        group.long 0x70--0x73 "BAM_TRUST_REG (at 0xFD444070) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0xD " [   13]   LOCK_EE_CTRL                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_VMID                                 = " 
        textline ""
        bitfld.long 0x0 0x7 " [   07]   BAM_RST_BLOCK                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_EE                                   = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_TEST_BUS_SEL"
        group.long 0x74--0x77 "BAM_TEST_BUS_SEL (at 0xFD444074) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x15 " [   21]   SW_EVENTS_ZERO                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x13--0x14 " [20:19]   SW_EVENTS_SEL                            = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x12 " [   18]   BAM_DATA_ERASE                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11 " [   17]   BAM_DATA_FLUSH                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   BAM_CLK_ALWAYS_ON                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x0--0x6 1  " [06:00]   BAM_TESTBUS_SEL                          = " 
        textline ""
      tree.end
      tree "BAM_TEST_BUS_REG"
        group.long 0x78--0x7B "BAM_TEST_BUS_REG (at 0xFD444078) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   BAM_TESTBUS_REG                          = " 
        textline ""
      tree.end
      tree "BAM_CNFG_BITS"
        group.long 0x7C--0x7F "BAM_CNFG_BITS (at 0xFD44407C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1E " [   30]   MULTIPLE_EVENTS_DESC_AVAIL_EN            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   MULTIPLE_EVENTS_SIZE_EN                  = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1C " [   28]   BAM_ZLT_W_CD_SUPPORT                     = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1B " [   27]   BAM_CD_ENABLE                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1A " [   26]   BAM_AU_ACCUMED                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x19 " [   25]   BAM_PSM_P_HD_DATA                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_REG_P_EN                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_WB_DSC_AVL_P_RST                     = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_WB_RETR_SVPNT                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_WB_CSW_ACK_IDL                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_WB_BLK_CSW                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x13 " [   19]   BAM_WB_P_RES                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x12 " [   18]   BAM_SI_P_RES                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11 " [   17]   BAM_AU_P_RES                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   BAM_PSM_P_RES                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0xF " [   15]   BAM_PSM_CSW_REQ                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0xE " [   14]   BAM_SB_CLK_REQ                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0xD " [   13]   BAM_IBC_DISABLE                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0xC " [   12]   BAM_NO_EXT_P_RST                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0xB " [   11]   BAM_FULL_PIPE                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   BAM_ADML_SYNC_BRIDGE                     = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_PIPE_CNFG                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_ADML_DEEP_CONS_FIFO                  = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   BAM_ADML_INCR4_EN_N                      = "  "0,1"
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE0"
        group.long 0x800--0x803 "BAM_IRQ_SRCS_EE0 (at 0xFD444800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE1"
        group.long 0x880--0x883 "BAM_IRQ_SRCS_EE1 (at 0xFD444880) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE2"
        group.long 0x900--0x903 "BAM_IRQ_SRCS_EE2 (at 0xFD444900) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE3"
        group.long 0x980--0x983 "BAM_IRQ_SRCS_EE3 (at 0xFD444980) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE4"
        group.long 0xA00--0xA03 "BAM_IRQ_SRCS_EE4 (at 0xFD444A00) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE5"
        group.long 0xA80--0xA83 "BAM_IRQ_SRCS_EE5 (at 0xFD444A80) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE6"
        group.long 0xB00--0xB03 "BAM_IRQ_SRCS_EE6 (at 0xFD444B00) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE7"
        group.long 0xB80--0xB83 "BAM_IRQ_SRCS_EE7 (at 0xFD444B80) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE0"
        group.long 0x804--0x807 "BAM_IRQ_SRCS_MSK_EE0 (at 0xFD444804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE1"
        group.long 0x884--0x887 "BAM_IRQ_SRCS_MSK_EE1 (at 0xFD444884) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE2"
        group.long 0x904--0x907 "BAM_IRQ_SRCS_MSK_EE2 (at 0xFD444904) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE3"
        group.long 0x984--0x987 "BAM_IRQ_SRCS_MSK_EE3 (at 0xFD444984) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE4"
        group.long 0xA04--0xA07 "BAM_IRQ_SRCS_MSK_EE4 (at 0xFD444A04) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE5"
        group.long 0xA84--0xA87 "BAM_IRQ_SRCS_MSK_EE5 (at 0xFD444A84) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE6"
        group.long 0xB04--0xB07 "BAM_IRQ_SRCS_MSK_EE6 (at 0xFD444B04) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE7"
        group.long 0xB84--0xB87 "BAM_IRQ_SRCS_MSK_EE7 (at 0xFD444B84) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE0"
        group.long 0x808--0x80B "BAM_IRQ_SRCS_UNMASKED_EE0 (at 0xFD444808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE1"
        group.long 0x888--0x88B "BAM_IRQ_SRCS_UNMASKED_EE1 (at 0xFD444888) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE2"
        group.long 0x908--0x90B "BAM_IRQ_SRCS_UNMASKED_EE2 (at 0xFD444908) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE3"
        group.long 0x988--0x98B "BAM_IRQ_SRCS_UNMASKED_EE3 (at 0xFD444988) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE4"
        group.long 0xA08--0xA0B "BAM_IRQ_SRCS_UNMASKED_EE4 (at 0xFD444A08) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE5"
        group.long 0xA88--0xA8B "BAM_IRQ_SRCS_UNMASKED_EE5 (at 0xFD444A88) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE6"
        group.long 0xB08--0xB0B "BAM_IRQ_SRCS_UNMASKED_EE6 (at 0xFD444B08) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE7"
        group.long 0xB88--0xB8B "BAM_IRQ_SRCS_UNMASKED_EE7 (at 0xFD444B88) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
;End of BAM Control Registers
tree.end
tree "Pipe 0"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL0"
        group.long 0x1000--0x1003 "BAM_P_CTRL0 (at 0xFD445000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST0"
        group.long 0x1004--0x1007 "BAM_P_RST0 (at 0xFD445004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT0"
        group.long 0x1008--0x100B "BAM_P_HALT0 (at 0xFD445008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG0"
        group.long 0x1030--0x1033 "BAM_P_TRUST_REG0 (at 0xFD445030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS0"
        group.long 0x1010--0x1013 "BAM_P_IRQ_STTS0 (at 0xFD445010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR0"
        group.long 0x1014--0x1017 "BAM_P_IRQ_CLR0 (at 0xFD445014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN0"
        group.long 0x1018--0x101B "BAM_P_IRQ_EN0 (at 0xFD445018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER0"
        group.long 0x101C--0x101F "BAM_P_TIMER0 (at 0xFD44501C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL0"
        group.long 0x1020--0x1023 "BAM_P_TIMER_CTRL0 (at 0xFD445020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND0"
        group.long 0x1024--0x1027 "BAM_P_PRDCR_SDBND0 (at 0xFD445024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND0"
        group.long 0x1028--0x102B "BAM_P_CNSMR_SDBND0 (at 0xFD445028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR0"
        group.long 0x182C--0x182F "BAM_P_EVNT_DEST_ADDR0 (at 0xFD44582C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG0"
        group.long 0x1818--0x181B "BAM_P_EVNT_REG0 (at 0xFD445818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS0"
        group.long 0x1800--0x1803 "BAM_P_SW_OFSTS0 (at 0xFD445800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR0"
        group.long 0x1824--0x1827 "BAM_P_DATA_FIFO_ADDR0 (at 0xFD445824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR0"
        group.long 0x181C--0x181F "BAM_P_DESC_FIFO_ADDR0 (at 0xFD44581C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD0"
        group.long 0x1828--0x182B "BAM_P_EVNT_GEN_TRSHLD0 (at 0xFD445828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES0"
        group.long 0x1820--0x1823 "BAM_P_FIFO_SIZES0 (at 0xFD445820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_0"
        group.long 0x1834--0x1837 "BAM_P_RETR_CNTXT_0 (at 0xFD445834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_0"
        group.long 0x1838--0x183B "BAM_P_SI_CNTXT_0 (at 0xFD445838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_0"
        group.long 0x1830--0x1833 "BAM_P_DF_CNTXT_0 (at 0xFD445830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_0"
        group.long 0x1804--0x1807 "BAM_P_AU_PSM_CNTXT_1_0 (at 0xFD445804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_0"
        group.long 0x1808--0x180B "BAM_P_PSM_CNTXT_2_0 (at 0xFD445808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_0"
        group.long 0x180C--0x180F "BAM_P_PSM_CNTXT_3_0 (at 0xFD44580C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_0"
        group.long 0x1810--0x1813 "BAM_P_PSM_CNTXT_4_0 (at 0xFD445810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_0"
        group.long 0x1814--0x1817 "BAM_P_PSM_CNTXT_5_0 (at 0xFD445814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 0
tree.end
tree "Pipe 1"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL1"
        group.long 0x2000--0x2003 "BAM_P_CTRL1 (at 0xFD446000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST1"
        group.long 0x2004--0x2007 "BAM_P_RST1 (at 0xFD446004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT1"
        group.long 0x2008--0x200B "BAM_P_HALT1 (at 0xFD446008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG1"
        group.long 0x2030--0x2033 "BAM_P_TRUST_REG1 (at 0xFD446030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS1"
        group.long 0x2010--0x2013 "BAM_P_IRQ_STTS1 (at 0xFD446010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR1"
        group.long 0x2014--0x2017 "BAM_P_IRQ_CLR1 (at 0xFD446014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN1"
        group.long 0x2018--0x201B "BAM_P_IRQ_EN1 (at 0xFD446018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER1"
        group.long 0x201C--0x201F "BAM_P_TIMER1 (at 0xFD44601C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL1"
        group.long 0x2020--0x2023 "BAM_P_TIMER_CTRL1 (at 0xFD446020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND1"
        group.long 0x2024--0x2027 "BAM_P_PRDCR_SDBND1 (at 0xFD446024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND1"
        group.long 0x2028--0x202B "BAM_P_CNSMR_SDBND1 (at 0xFD446028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR1"
        group.long 0x282C--0x282F "BAM_P_EVNT_DEST_ADDR1 (at 0xFD44682C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG1"
        group.long 0x2818--0x281B "BAM_P_EVNT_REG1 (at 0xFD446818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS1"
        group.long 0x2800--0x2803 "BAM_P_SW_OFSTS1 (at 0xFD446800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR1"
        group.long 0x2824--0x2827 "BAM_P_DATA_FIFO_ADDR1 (at 0xFD446824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR1"
        group.long 0x281C--0x281F "BAM_P_DESC_FIFO_ADDR1 (at 0xFD44681C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD1"
        group.long 0x2828--0x282B "BAM_P_EVNT_GEN_TRSHLD1 (at 0xFD446828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES1"
        group.long 0x2820--0x2823 "BAM_P_FIFO_SIZES1 (at 0xFD446820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_1"
        group.long 0x2834--0x2837 "BAM_P_RETR_CNTXT_1 (at 0xFD446834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_1"
        group.long 0x2838--0x283B "BAM_P_SI_CNTXT_1 (at 0xFD446838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_1"
        group.long 0x2830--0x2833 "BAM_P_DF_CNTXT_1 (at 0xFD446830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_1"
        group.long 0x2804--0x2807 "BAM_P_AU_PSM_CNTXT_1_1 (at 0xFD446804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_1"
        group.long 0x2808--0x280B "BAM_P_PSM_CNTXT_2_1 (at 0xFD446808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_1"
        group.long 0x280C--0x280F "BAM_P_PSM_CNTXT_3_1 (at 0xFD44680C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_1"
        group.long 0x2810--0x2813 "BAM_P_PSM_CNTXT_4_1 (at 0xFD446810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_1"
        group.long 0x2814--0x2817 "BAM_P_PSM_CNTXT_5_1 (at 0xFD446814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 1
tree.end
tree "Pipe 2"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL2"
        group.long 0x3000--0x3003 "BAM_P_CTRL2 (at 0xFD447000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST2"
        group.long 0x3004--0x3007 "BAM_P_RST2 (at 0xFD447004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT2"
        group.long 0x3008--0x300B "BAM_P_HALT2 (at 0xFD447008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG2"
        group.long 0x3030--0x3033 "BAM_P_TRUST_REG2 (at 0xFD447030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS2"
        group.long 0x3010--0x3013 "BAM_P_IRQ_STTS2 (at 0xFD447010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR2"
        group.long 0x3014--0x3017 "BAM_P_IRQ_CLR2 (at 0xFD447014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN2"
        group.long 0x3018--0x301B "BAM_P_IRQ_EN2 (at 0xFD447018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER2"
        group.long 0x301C--0x301F "BAM_P_TIMER2 (at 0xFD44701C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL2"
        group.long 0x3020--0x3023 "BAM_P_TIMER_CTRL2 (at 0xFD447020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND2"
        group.long 0x3024--0x3027 "BAM_P_PRDCR_SDBND2 (at 0xFD447024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND2"
        group.long 0x3028--0x302B "BAM_P_CNSMR_SDBND2 (at 0xFD447028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR2"
        group.long 0x382C--0x382F "BAM_P_EVNT_DEST_ADDR2 (at 0xFD44782C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG2"
        group.long 0x3818--0x381B "BAM_P_EVNT_REG2 (at 0xFD447818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS2"
        group.long 0x3800--0x3803 "BAM_P_SW_OFSTS2 (at 0xFD447800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR2"
        group.long 0x3824--0x3827 "BAM_P_DATA_FIFO_ADDR2 (at 0xFD447824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR2"
        group.long 0x381C--0x381F "BAM_P_DESC_FIFO_ADDR2 (at 0xFD44781C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD2"
        group.long 0x3828--0x382B "BAM_P_EVNT_GEN_TRSHLD2 (at 0xFD447828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES2"
        group.long 0x3820--0x3823 "BAM_P_FIFO_SIZES2 (at 0xFD447820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_2"
        group.long 0x3834--0x3837 "BAM_P_RETR_CNTXT_2 (at 0xFD447834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_2"
        group.long 0x3838--0x383B "BAM_P_SI_CNTXT_2 (at 0xFD447838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_2"
        group.long 0x3830--0x3833 "BAM_P_DF_CNTXT_2 (at 0xFD447830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_2"
        group.long 0x3804--0x3807 "BAM_P_AU_PSM_CNTXT_1_2 (at 0xFD447804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_2"
        group.long 0x3808--0x380B "BAM_P_PSM_CNTXT_2_2 (at 0xFD447808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_2"
        group.long 0x380C--0x380F "BAM_P_PSM_CNTXT_3_2 (at 0xFD44780C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_2"
        group.long 0x3810--0x3813 "BAM_P_PSM_CNTXT_4_2 (at 0xFD447810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_2"
        group.long 0x3814--0x3817 "BAM_P_PSM_CNTXT_5_2 (at 0xFD447814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 2
tree.end
tree "Pipe 3"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL3"
        group.long 0x4000--0x4003 "BAM_P_CTRL3 (at 0xFD448000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST3"
        group.long 0x4004--0x4007 "BAM_P_RST3 (at 0xFD448004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT3"
        group.long 0x4008--0x400B "BAM_P_HALT3 (at 0xFD448008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG3"
        group.long 0x4030--0x4033 "BAM_P_TRUST_REG3 (at 0xFD448030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS3"
        group.long 0x4010--0x4013 "BAM_P_IRQ_STTS3 (at 0xFD448010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR3"
        group.long 0x4014--0x4017 "BAM_P_IRQ_CLR3 (at 0xFD448014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN3"
        group.long 0x4018--0x401B "BAM_P_IRQ_EN3 (at 0xFD448018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER3"
        group.long 0x401C--0x401F "BAM_P_TIMER3 (at 0xFD44801C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL3"
        group.long 0x4020--0x4023 "BAM_P_TIMER_CTRL3 (at 0xFD448020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND3"
        group.long 0x4024--0x4027 "BAM_P_PRDCR_SDBND3 (at 0xFD448024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND3"
        group.long 0x4028--0x402B "BAM_P_CNSMR_SDBND3 (at 0xFD448028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR3"
        group.long 0x482C--0x482F "BAM_P_EVNT_DEST_ADDR3 (at 0xFD44882C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG3"
        group.long 0x4818--0x481B "BAM_P_EVNT_REG3 (at 0xFD448818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS3"
        group.long 0x4800--0x4803 "BAM_P_SW_OFSTS3 (at 0xFD448800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR3"
        group.long 0x4824--0x4827 "BAM_P_DATA_FIFO_ADDR3 (at 0xFD448824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR3"
        group.long 0x481C--0x481F "BAM_P_DESC_FIFO_ADDR3 (at 0xFD44881C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD3"
        group.long 0x4828--0x482B "BAM_P_EVNT_GEN_TRSHLD3 (at 0xFD448828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES3"
        group.long 0x4820--0x4823 "BAM_P_FIFO_SIZES3 (at 0xFD448820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_3"
        group.long 0x4834--0x4837 "BAM_P_RETR_CNTXT_3 (at 0xFD448834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_3"
        group.long 0x4838--0x483B "BAM_P_SI_CNTXT_3 (at 0xFD448838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_3"
        group.long 0x4830--0x4833 "BAM_P_DF_CNTXT_3 (at 0xFD448830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_3"
        group.long 0x4804--0x4807 "BAM_P_AU_PSM_CNTXT_1_3 (at 0xFD448804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_3"
        group.long 0x4808--0x480B "BAM_P_PSM_CNTXT_2_3 (at 0xFD448808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_3"
        group.long 0x480C--0x480F "BAM_P_PSM_CNTXT_3_3 (at 0xFD44880C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_3"
        group.long 0x4810--0x4813 "BAM_P_PSM_CNTXT_4_3 (at 0xFD448810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_3"
        group.long 0x4814--0x4817 "BAM_P_PSM_CNTXT_5_3 (at 0xFD448814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 3
tree.end
tree "Pipe 4"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL4"
        group.long 0x5000--0x5003 "BAM_P_CTRL4 (at 0xFD449000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST4"
        group.long 0x5004--0x5007 "BAM_P_RST4 (at 0xFD449004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT4"
        group.long 0x5008--0x500B "BAM_P_HALT4 (at 0xFD449008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG4"
        group.long 0x5030--0x5033 "BAM_P_TRUST_REG4 (at 0xFD449030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS4"
        group.long 0x5010--0x5013 "BAM_P_IRQ_STTS4 (at 0xFD449010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR4"
        group.long 0x5014--0x5017 "BAM_P_IRQ_CLR4 (at 0xFD449014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN4"
        group.long 0x5018--0x501B "BAM_P_IRQ_EN4 (at 0xFD449018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER4"
        group.long 0x501C--0x501F "BAM_P_TIMER4 (at 0xFD44901C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL4"
        group.long 0x5020--0x5023 "BAM_P_TIMER_CTRL4 (at 0xFD449020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND4"
        group.long 0x5024--0x5027 "BAM_P_PRDCR_SDBND4 (at 0xFD449024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND4"
        group.long 0x5028--0x502B "BAM_P_CNSMR_SDBND4 (at 0xFD449028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR4"
        group.long 0x582C--0x582F "BAM_P_EVNT_DEST_ADDR4 (at 0xFD44982C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG4"
        group.long 0x5818--0x581B "BAM_P_EVNT_REG4 (at 0xFD449818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS4"
        group.long 0x5800--0x5803 "BAM_P_SW_OFSTS4 (at 0xFD449800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR4"
        group.long 0x5824--0x5827 "BAM_P_DATA_FIFO_ADDR4 (at 0xFD449824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR4"
        group.long 0x581C--0x581F "BAM_P_DESC_FIFO_ADDR4 (at 0xFD44981C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD4"
        group.long 0x5828--0x582B "BAM_P_EVNT_GEN_TRSHLD4 (at 0xFD449828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES4"
        group.long 0x5820--0x5823 "BAM_P_FIFO_SIZES4 (at 0xFD449820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_4"
        group.long 0x5834--0x5837 "BAM_P_RETR_CNTXT_4 (at 0xFD449834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_4"
        group.long 0x5838--0x583B "BAM_P_SI_CNTXT_4 (at 0xFD449838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_4"
        group.long 0x5830--0x5833 "BAM_P_DF_CNTXT_4 (at 0xFD449830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_4"
        group.long 0x5804--0x5807 "BAM_P_AU_PSM_CNTXT_1_4 (at 0xFD449804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_4"
        group.long 0x5808--0x580B "BAM_P_PSM_CNTXT_2_4 (at 0xFD449808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_4"
        group.long 0x580C--0x580F "BAM_P_PSM_CNTXT_3_4 (at 0xFD44980C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_4"
        group.long 0x5810--0x5813 "BAM_P_PSM_CNTXT_4_4 (at 0xFD449810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_4"
        group.long 0x5814--0x5817 "BAM_P_PSM_CNTXT_5_4 (at 0xFD449814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 4
tree.end
tree "Pipe 5"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL5"
        group.long 0x6000--0x6003 "BAM_P_CTRL5 (at 0xFD44A000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST5"
        group.long 0x6004--0x6007 "BAM_P_RST5 (at 0xFD44A004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT5"
        group.long 0x6008--0x600B "BAM_P_HALT5 (at 0xFD44A008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG5"
        group.long 0x6030--0x6033 "BAM_P_TRUST_REG5 (at 0xFD44A030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS5"
        group.long 0x6010--0x6013 "BAM_P_IRQ_STTS5 (at 0xFD44A010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR5"
        group.long 0x6014--0x6017 "BAM_P_IRQ_CLR5 (at 0xFD44A014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN5"
        group.long 0x6018--0x601B "BAM_P_IRQ_EN5 (at 0xFD44A018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER5"
        group.long 0x601C--0x601F "BAM_P_TIMER5 (at 0xFD44A01C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL5"
        group.long 0x6020--0x6023 "BAM_P_TIMER_CTRL5 (at 0xFD44A020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND5"
        group.long 0x6024--0x6027 "BAM_P_PRDCR_SDBND5 (at 0xFD44A024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND5"
        group.long 0x6028--0x602B "BAM_P_CNSMR_SDBND5 (at 0xFD44A028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR5"
        group.long 0x682C--0x682F "BAM_P_EVNT_DEST_ADDR5 (at 0xFD44A82C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG5"
        group.long 0x6818--0x681B "BAM_P_EVNT_REG5 (at 0xFD44A818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS5"
        group.long 0x6800--0x6803 "BAM_P_SW_OFSTS5 (at 0xFD44A800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR5"
        group.long 0x6824--0x6827 "BAM_P_DATA_FIFO_ADDR5 (at 0xFD44A824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR5"
        group.long 0x681C--0x681F "BAM_P_DESC_FIFO_ADDR5 (at 0xFD44A81C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD5"
        group.long 0x6828--0x682B "BAM_P_EVNT_GEN_TRSHLD5 (at 0xFD44A828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES5"
        group.long 0x6820--0x6823 "BAM_P_FIFO_SIZES5 (at 0xFD44A820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_5"
        group.long 0x6834--0x6837 "BAM_P_RETR_CNTXT_5 (at 0xFD44A834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_5"
        group.long 0x6838--0x683B "BAM_P_SI_CNTXT_5 (at 0xFD44A838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_5"
        group.long 0x6830--0x6833 "BAM_P_DF_CNTXT_5 (at 0xFD44A830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_5"
        group.long 0x6804--0x6807 "BAM_P_AU_PSM_CNTXT_1_5 (at 0xFD44A804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_5"
        group.long 0x6808--0x680B "BAM_P_PSM_CNTXT_2_5 (at 0xFD44A808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_5"
        group.long 0x680C--0x680F "BAM_P_PSM_CNTXT_3_5 (at 0xFD44A80C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_5"
        group.long 0x6810--0x6813 "BAM_P_PSM_CNTXT_4_5 (at 0xFD44A810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_5"
        group.long 0x6814--0x6817 "BAM_P_PSM_CNTXT_5_5 (at 0xFD44A814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 5
tree.end
tree "Pipe 6"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL6"
        group.long 0x7000--0x7003 "BAM_P_CTRL6 (at 0xFD44B000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST6"
        group.long 0x7004--0x7007 "BAM_P_RST6 (at 0xFD44B004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT6"
        group.long 0x7008--0x700B "BAM_P_HALT6 (at 0xFD44B008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG6"
        group.long 0x7030--0x7033 "BAM_P_TRUST_REG6 (at 0xFD44B030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS6"
        group.long 0x7010--0x7013 "BAM_P_IRQ_STTS6 (at 0xFD44B010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR6"
        group.long 0x7014--0x7017 "BAM_P_IRQ_CLR6 (at 0xFD44B014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN6"
        group.long 0x7018--0x701B "BAM_P_IRQ_EN6 (at 0xFD44B018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER6"
        group.long 0x701C--0x701F "BAM_P_TIMER6 (at 0xFD44B01C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL6"
        group.long 0x7020--0x7023 "BAM_P_TIMER_CTRL6 (at 0xFD44B020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND6"
        group.long 0x7024--0x7027 "BAM_P_PRDCR_SDBND6 (at 0xFD44B024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND6"
        group.long 0x7028--0x702B "BAM_P_CNSMR_SDBND6 (at 0xFD44B028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR6"
        group.long 0x782C--0x782F "BAM_P_EVNT_DEST_ADDR6 (at 0xFD44B82C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG6"
        group.long 0x7818--0x781B "BAM_P_EVNT_REG6 (at 0xFD44B818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS6"
        group.long 0x7800--0x7803 "BAM_P_SW_OFSTS6 (at 0xFD44B800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR6"
        group.long 0x7824--0x7827 "BAM_P_DATA_FIFO_ADDR6 (at 0xFD44B824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR6"
        group.long 0x781C--0x781F "BAM_P_DESC_FIFO_ADDR6 (at 0xFD44B81C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD6"
        group.long 0x7828--0x782B "BAM_P_EVNT_GEN_TRSHLD6 (at 0xFD44B828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES6"
        group.long 0x7820--0x7823 "BAM_P_FIFO_SIZES6 (at 0xFD44B820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_6"
        group.long 0x7834--0x7837 "BAM_P_RETR_CNTXT_6 (at 0xFD44B834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_6"
        group.long 0x7838--0x783B "BAM_P_SI_CNTXT_6 (at 0xFD44B838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_6"
        group.long 0x7830--0x7833 "BAM_P_DF_CNTXT_6 (at 0xFD44B830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_6"
        group.long 0x7804--0x7807 "BAM_P_AU_PSM_CNTXT_1_6 (at 0xFD44B804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_6"
        group.long 0x7808--0x780B "BAM_P_PSM_CNTXT_2_6 (at 0xFD44B808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_6"
        group.long 0x780C--0x780F "BAM_P_PSM_CNTXT_3_6 (at 0xFD44B80C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_6"
        group.long 0x7810--0x7813 "BAM_P_PSM_CNTXT_4_6 (at 0xFD44B810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_6"
        group.long 0x7814--0x7817 "BAM_P_PSM_CNTXT_5_6 (at 0xFD44B814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 6
tree.end
tree "Pipe 7"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL7"
        group.long 0x8000--0x8003 "BAM_P_CTRL7 (at 0xFD44C000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST7"
        group.long 0x8004--0x8007 "BAM_P_RST7 (at 0xFD44C004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT7"
        group.long 0x8008--0x800B "BAM_P_HALT7 (at 0xFD44C008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG7"
        group.long 0x8030--0x8033 "BAM_P_TRUST_REG7 (at 0xFD44C030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS7"
        group.long 0x8010--0x8013 "BAM_P_IRQ_STTS7 (at 0xFD44C010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR7"
        group.long 0x8014--0x8017 "BAM_P_IRQ_CLR7 (at 0xFD44C014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN7"
        group.long 0x8018--0x801B "BAM_P_IRQ_EN7 (at 0xFD44C018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER7"
        group.long 0x801C--0x801F "BAM_P_TIMER7 (at 0xFD44C01C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL7"
        group.long 0x8020--0x8023 "BAM_P_TIMER_CTRL7 (at 0xFD44C020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND7"
        group.long 0x8024--0x8027 "BAM_P_PRDCR_SDBND7 (at 0xFD44C024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND7"
        group.long 0x8028--0x802B "BAM_P_CNSMR_SDBND7 (at 0xFD44C028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR7"
        group.long 0x882C--0x882F "BAM_P_EVNT_DEST_ADDR7 (at 0xFD44C82C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG7"
        group.long 0x8818--0x881B "BAM_P_EVNT_REG7 (at 0xFD44C818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS7"
        group.long 0x8800--0x8803 "BAM_P_SW_OFSTS7 (at 0xFD44C800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR7"
        group.long 0x8824--0x8827 "BAM_P_DATA_FIFO_ADDR7 (at 0xFD44C824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR7"
        group.long 0x881C--0x881F "BAM_P_DESC_FIFO_ADDR7 (at 0xFD44C81C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD7"
        group.long 0x8828--0x882B "BAM_P_EVNT_GEN_TRSHLD7 (at 0xFD44C828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES7"
        group.long 0x8820--0x8823 "BAM_P_FIFO_SIZES7 (at 0xFD44C820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_7"
        group.long 0x8834--0x8837 "BAM_P_RETR_CNTXT_7 (at 0xFD44C834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_7"
        group.long 0x8838--0x883B "BAM_P_SI_CNTXT_7 (at 0xFD44C838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_7"
        group.long 0x8830--0x8833 "BAM_P_DF_CNTXT_7 (at 0xFD44C830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_7"
        group.long 0x8804--0x8807 "BAM_P_AU_PSM_CNTXT_1_7 (at 0xFD44C804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_7"
        group.long 0x8808--0x880B "BAM_P_PSM_CNTXT_2_7 (at 0xFD44C808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_7"
        group.long 0x880C--0x880F "BAM_P_PSM_CNTXT_3_7 (at 0xFD44C80C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_7"
        group.long 0x8810--0x8813 "BAM_P_PSM_CNTXT_4_7 (at 0xFD44C810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_7"
        group.long 0x8814--0x8817 "BAM_P_PSM_CNTXT_5_7 (at 0xFD44C814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 7
tree.end
tree.end
;Block Per Data Ends

base ad:0xFE104000
tree "LPASS_Slimbus"
tree "BAM Control Registers"
      tree "BAM_CTRL"
        group.long 0x0--0x3 "BAM_CTRL (at 0xFE104000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x13 " [   19]   CACHE_MISS_ERR_RESP_EN                   = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11--0x12 " [18:17]   LOCAL_CLK_GATING                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   IBC_DISABLE                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0xF " [   15]   BAM_CACHED_DESC_STORE                    = "  "0,1"
        textline ""
        bitfld.long 0x0 0xD--0xE " [14:13]   BAM_DESC_CACHE_SEL                       = "  "0,1,2,3"
        textline ""
        hexmask.long.word 0x0 0x5--0xB 1  " [11:05]   BAM_TESTBUS_SEL                          = " 
        textline ""
        bitfld.long 0x0 0x4 " [   04]   BAM_EN_ACCUM                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_EN                                   = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   BAM_SW_RST                               = "  "0,1"
        textline ""
      tree.end
      tree "BAM_REVISION"
        group.long 0x4--0x7 "BAM_REVISION (at 0xFE104004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x18--0x1F 1  " [31:24]   INACTIV_TMR_BASE                         = " 
        textline ""
        bitfld.long 0x0 0x17 " [   23]   CMD_DESC_EN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15--0x16 " [22:21]   DESC_CACHE_DEPTH                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   NUM_INACTIV_TMRS                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x13 " [   19]   INACTIV_TMRS_EXST                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x12 " [   18]   HIGH_FREQUENCY_BAM                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11 " [   17]   BAM_HAS_NO_BYPASS                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   SECURED                                  = "  "0,1"
        textline ""
        bitfld.long 0x0 0xF " [   15]   USE_VMIDMT                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0xE " [   14]   AXI_ACTIVE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0xD " [   13]   CE_BUFFER_SIZE                           = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x8--0xB 1  " [11:08]   NUM_EES                                  = " 
        textline ""
        hexmask.long.word 0x0 0x0--0x7 1  " [07:00]   REVISION                                 = " 
        textline ""
      tree.end
      tree "BAM_SW_VERSION"
        group.long 0x80--0x83 "BAM_SW_VERSION (at 0xFE104080) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x1C--0x1F 1  " [31:28]   MAJOR                                    = " 
        textline ""
        hexmask.long.word 0x0 0x10--0x1B 1  " [27:16]   MINOR                                    = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   STEP                                     = " 
        textline ""
      tree.end
      tree "BAM_NUM_PIPES"
        group.long 0x3C--0x3F "BAM_NUM_PIPES (at 0xFE10403C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x18--0x1F 1  " [31:24]   BAM_NON_PIPE_GRP                         = " 
        textline ""
        hexmask.long.word 0x0 0x10--0x17 1  " [23:16]   PERIPH_NON_PIPE_GRP                      = " 
        textline ""
        hexmask.long.word 0x0 0x0--0x7 1  " [07:00]   BAM_NUM_PIPES                            = " 
        textline ""
      tree.end
      tree "BAM_TIMER"
        group.long 0x40--0x43 "BAM_TIMER (at 0xFE104040) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   TIMER                                    = " 
        textline ""
      tree.end
      tree "BAM_TIMER_CTRL"
        group.long 0x44--0x47 "BAM_TIMER_CTRL (at 0xFE104044) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   TIMER_RST                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   TIMER_RUN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   TIMER_MODE                               = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   TIMER_TRSHLD                             = " 
        textline ""
      tree.end
      tree "BAM_DESC_CNT_TRSHLD"
        group.long 0x8--0xB "BAM_DESC_CNT_TRSHLD (at 0xFE104008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   CNT_TRSHLD                               = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS"
        group.long 0xC--0xF "BAM_IRQ_SRCS (at 0xFE10400C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK"
        group.long 0x10--0x13 "BAM_IRQ_SRCS_MSK (at 0xFE104010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED"
        group.long 0x30--0x33 "BAM_IRQ_SRCS_UNMASKED (at 0xFE104030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_STTS"
        group.long 0x14--0x17 "BAM_IRQ_STTS (at 0xFE104014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x4 " [   04]   BAM_TIMER_IRQ                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   BAM_EMPTY_IRQ                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_ERROR_IRQ                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_HRESP_ERR_IRQ                        = "  "0,1"
        textline ""
      tree.end
      tree "BAM_IRQ_CLR"
        group.long 0x18--0x1B "BAM_IRQ_CLR (at 0xFE104018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x4 " [   04]   BAM_TIMER_CLR                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   BAM_EMPTY_CLR                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_ERROR_CLR                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_HRESP_ERR_CLR                        = "  "0,1"
        textline ""
      tree.end
      tree "BAM_IRQ_EN"
        group.long 0x1C--0x1F "BAM_IRQ_EN (at 0xFE10401C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x4 " [   04]   BAM_TIMER_EN                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   BAM_EMPTY_EN                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_ERROR_EN                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_HRESP_ERR_EN                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_AHB_MASTER_ERR_CTRLS"
        group.long 0x24--0x27 "BAM_AHB_MASTER_ERR_CTRLS (at 0xFE104024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x12--0x16 1  " [22:18]   BAM_ERR_HVMID                            = " 
        textline ""
        bitfld.long 0x0 0x11 " [   17]   BAM_ERR_DIRECT_MODE                      = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0xC--0x10 1  " [16:12]   BAM_ERR_HCID                             = " 
        textline ""
        hexmask.long.word 0x0 0x8--0xB 1  " [11:08]   BAM_ERR_HPROT                            = " 
        textline ""
        bitfld.long 0x0 0x5--0x7 " [07:05]   BAM_ERR_HBURST                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x3--0x4 " [04:03]   BAM_ERR_HSIZE                            = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_ERR_HWRITE                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0--0x1 " [01:00]   BAM_ERR_HTRANS                           = "  "0,1,2,3"
        textline ""
      tree.end
      tree "BAM_AHB_MASTER_ERR_ADDR"
        group.long 0x28--0x2B "BAM_AHB_MASTER_ERR_ADDR (at 0xFE104028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   BAM_ERR_ADDR                             = " 
        textline ""
      tree.end
      tree "BAM_AHB_MASTER_ERR_DATA"
        group.long 0x2C--0x2F "BAM_AHB_MASTER_ERR_DATA (at 0xFE10402C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   BAM_ERR_DATA                             = " 
        textline ""
      tree.end
      tree "BAM_TRUST_REG"
        group.long 0x70--0x73 "BAM_TRUST_REG (at 0xFE104070) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0xD " [   13]   LOCK_EE_CTRL                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_VMID                                 = " 
        textline ""
        bitfld.long 0x0 0x7 " [   07]   BAM_RST_BLOCK                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_EE                                   = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_TEST_BUS_SEL"
        group.long 0x74--0x77 "BAM_TEST_BUS_SEL (at 0xFE104074) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x15 " [   21]   SW_EVENTS_ZERO                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x13--0x14 " [20:19]   SW_EVENTS_SEL                            = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x12 " [   18]   BAM_DATA_ERASE                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11 " [   17]   BAM_DATA_FLUSH                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   BAM_CLK_ALWAYS_ON                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x0--0x6 1  " [06:00]   BAM_TESTBUS_SEL                          = " 
        textline ""
      tree.end
      tree "BAM_TEST_BUS_REG"
        group.long 0x78--0x7B "BAM_TEST_BUS_REG (at 0xFE104078) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   BAM_TESTBUS_REG                          = " 
        textline ""
      tree.end
      tree "BAM_CNFG_BITS"
        group.long 0x7C--0x7F "BAM_CNFG_BITS (at 0xFE10407C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1C " [   28]   BAM_ZLT_W_CD_SUPPORT                     = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1B " [   27]   BAM_CD_ENABLE                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1A " [   26]   BAM_AU_ACCUMED                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x19 " [   25]   BAM_PSM_P_HD_DATA                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_REG_P_EN                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_WB_DSC_AVL_P_RST                     = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_WB_RETR_SVPNT                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_WB_CSW_ACK_IDL                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_WB_BLK_CSW                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x13 " [   19]   BAM_WB_P_RES                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x12 " [   18]   BAM_SI_P_RES                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11 " [   17]   BAM_AU_P_RES                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   BAM_PSM_P_RES                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0xF " [   15]   BAM_PSM_CSW_REQ                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0xE " [   14]   BAM_SB_CLK_REQ                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0xD " [   13]   BAM_IBC_DISABLE                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0xC " [   12]   BAM_NO_EXT_P_RST                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0xB " [   11]   BAM_FULL_PIPE                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   BAM_ADML_SYNC_BRIDGE                     = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_PIPE_CNFG                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_ADML_DEEP_CONS_FIFO                  = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   BAM_ADML_INCR4_EN_N                      = "  "0,1"
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE0"
        group.long 0x800--0x803 "BAM_IRQ_SRCS_EE0 (at 0xFE104800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE1"
        group.long 0x880--0x883 "BAM_IRQ_SRCS_EE1 (at 0xFE104880) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE2"
        group.long 0x900--0x903 "BAM_IRQ_SRCS_EE2 (at 0xFE104900) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE3"
        group.long 0x980--0x983 "BAM_IRQ_SRCS_EE3 (at 0xFE104980) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE4"
        group.long 0xA00--0xA03 "BAM_IRQ_SRCS_EE4 (at 0xFE104A00) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE5"
        group.long 0xA80--0xA83 "BAM_IRQ_SRCS_EE5 (at 0xFE104A80) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE6"
        group.long 0xB00--0xB03 "BAM_IRQ_SRCS_EE6 (at 0xFE104B00) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE7"
        group.long 0xB80--0xB83 "BAM_IRQ_SRCS_EE7 (at 0xFE104B80) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE0"
        group.long 0x804--0x807 "BAM_IRQ_SRCS_MSK_EE0 (at 0xFE104804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE1"
        group.long 0x884--0x887 "BAM_IRQ_SRCS_MSK_EE1 (at 0xFE104884) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE2"
        group.long 0x904--0x907 "BAM_IRQ_SRCS_MSK_EE2 (at 0xFE104904) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE3"
        group.long 0x984--0x987 "BAM_IRQ_SRCS_MSK_EE3 (at 0xFE104984) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE4"
        group.long 0xA04--0xA07 "BAM_IRQ_SRCS_MSK_EE4 (at 0xFE104A04) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE5"
        group.long 0xA84--0xA87 "BAM_IRQ_SRCS_MSK_EE5 (at 0xFE104A84) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE6"
        group.long 0xB04--0xB07 "BAM_IRQ_SRCS_MSK_EE6 (at 0xFE104B04) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE7"
        group.long 0xB84--0xB87 "BAM_IRQ_SRCS_MSK_EE7 (at 0xFE104B84) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE0"
        group.long 0x808--0x80B "BAM_IRQ_SRCS_UNMASKED_EE0 (at 0xFE104808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE1"
        group.long 0x888--0x88B "BAM_IRQ_SRCS_UNMASKED_EE1 (at 0xFE104888) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE2"
        group.long 0x908--0x90B "BAM_IRQ_SRCS_UNMASKED_EE2 (at 0xFE104908) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE3"
        group.long 0x988--0x98B "BAM_IRQ_SRCS_UNMASKED_EE3 (at 0xFE104988) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE4"
        group.long 0xA08--0xA0B "BAM_IRQ_SRCS_UNMASKED_EE4 (at 0xFE104A08) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE5"
        group.long 0xA88--0xA8B "BAM_IRQ_SRCS_UNMASKED_EE5 (at 0xFE104A88) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE6"
        group.long 0xB08--0xB0B "BAM_IRQ_SRCS_UNMASKED_EE6 (at 0xFE104B08) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE7"
        group.long 0xB88--0xB8B "BAM_IRQ_SRCS_UNMASKED_EE7 (at 0xFE104B88) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
;End of BAM Control Registers
tree.end
tree "Pipe 0"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL0"
        group.long 0x1000--0x1003 "BAM_P_CTRL0 (at 0xFE105000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST0"
        group.long 0x1004--0x1007 "BAM_P_RST0 (at 0xFE105004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT0"
        group.long 0x1008--0x100B "BAM_P_HALT0 (at 0xFE105008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG0"
        group.long 0x1030--0x1033 "BAM_P_TRUST_REG0 (at 0xFE105030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS0"
        group.long 0x1010--0x1013 "BAM_P_IRQ_STTS0 (at 0xFE105010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR0"
        group.long 0x1014--0x1017 "BAM_P_IRQ_CLR0 (at 0xFE105014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN0"
        group.long 0x1018--0x101B "BAM_P_IRQ_EN0 (at 0xFE105018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER0"
        group.long 0x101C--0x101F "BAM_P_TIMER0 (at 0xFE10501C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL0"
        group.long 0x1020--0x1023 "BAM_P_TIMER_CTRL0 (at 0xFE105020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND0"
        group.long 0x1024--0x1027 "BAM_P_PRDCR_SDBND0 (at 0xFE105024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND0"
        group.long 0x1028--0x102B "BAM_P_CNSMR_SDBND0 (at 0xFE105028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR0"
        group.long 0x182C--0x182F "BAM_P_EVNT_DEST_ADDR0 (at 0xFE10582C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG0"
        group.long 0x1818--0x181B "BAM_P_EVNT_REG0 (at 0xFE105818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS0"
        group.long 0x1800--0x1803 "BAM_P_SW_OFSTS0 (at 0xFE105800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR0"
        group.long 0x1824--0x1827 "BAM_P_DATA_FIFO_ADDR0 (at 0xFE105824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR0"
        group.long 0x181C--0x181F "BAM_P_DESC_FIFO_ADDR0 (at 0xFE10581C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD0"
        group.long 0x1828--0x182B "BAM_P_EVNT_GEN_TRSHLD0 (at 0xFE105828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES0"
        group.long 0x1820--0x1823 "BAM_P_FIFO_SIZES0 (at 0xFE105820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_0"
        group.long 0x1834--0x1837 "BAM_P_RETR_CNTXT_0 (at 0xFE105834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_0"
        group.long 0x1838--0x183B "BAM_P_SI_CNTXT_0 (at 0xFE105838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_0"
        group.long 0x1830--0x1833 "BAM_P_DF_CNTXT_0 (at 0xFE105830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_0"
        group.long 0x1804--0x1807 "BAM_P_AU_PSM_CNTXT_1_0 (at 0xFE105804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_0"
        group.long 0x1808--0x180B "BAM_P_PSM_CNTXT_2_0 (at 0xFE105808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_0"
        group.long 0x180C--0x180F "BAM_P_PSM_CNTXT_3_0 (at 0xFE10580C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_0"
        group.long 0x1810--0x1813 "BAM_P_PSM_CNTXT_4_0 (at 0xFE105810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_0"
        group.long 0x1814--0x1817 "BAM_P_PSM_CNTXT_5_0 (at 0xFE105814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 0
tree.end
tree "Pipe 1"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL1"
        group.long 0x2000--0x2003 "BAM_P_CTRL1 (at 0xFE106000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST1"
        group.long 0x2004--0x2007 "BAM_P_RST1 (at 0xFE106004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT1"
        group.long 0x2008--0x200B "BAM_P_HALT1 (at 0xFE106008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG1"
        group.long 0x2030--0x2033 "BAM_P_TRUST_REG1 (at 0xFE106030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS1"
        group.long 0x2010--0x2013 "BAM_P_IRQ_STTS1 (at 0xFE106010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR1"
        group.long 0x2014--0x2017 "BAM_P_IRQ_CLR1 (at 0xFE106014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN1"
        group.long 0x2018--0x201B "BAM_P_IRQ_EN1 (at 0xFE106018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER1"
        group.long 0x201C--0x201F "BAM_P_TIMER1 (at 0xFE10601C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL1"
        group.long 0x2020--0x2023 "BAM_P_TIMER_CTRL1 (at 0xFE106020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND1"
        group.long 0x2024--0x2027 "BAM_P_PRDCR_SDBND1 (at 0xFE106024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND1"
        group.long 0x2028--0x202B "BAM_P_CNSMR_SDBND1 (at 0xFE106028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR1"
        group.long 0x282C--0x282F "BAM_P_EVNT_DEST_ADDR1 (at 0xFE10682C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG1"
        group.long 0x2818--0x281B "BAM_P_EVNT_REG1 (at 0xFE106818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS1"
        group.long 0x2800--0x2803 "BAM_P_SW_OFSTS1 (at 0xFE106800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR1"
        group.long 0x2824--0x2827 "BAM_P_DATA_FIFO_ADDR1 (at 0xFE106824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR1"
        group.long 0x281C--0x281F "BAM_P_DESC_FIFO_ADDR1 (at 0xFE10681C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD1"
        group.long 0x2828--0x282B "BAM_P_EVNT_GEN_TRSHLD1 (at 0xFE106828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES1"
        group.long 0x2820--0x2823 "BAM_P_FIFO_SIZES1 (at 0xFE106820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_1"
        group.long 0x2834--0x2837 "BAM_P_RETR_CNTXT_1 (at 0xFE106834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_1"
        group.long 0x2838--0x283B "BAM_P_SI_CNTXT_1 (at 0xFE106838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_1"
        group.long 0x2830--0x2833 "BAM_P_DF_CNTXT_1 (at 0xFE106830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_1"
        group.long 0x2804--0x2807 "BAM_P_AU_PSM_CNTXT_1_1 (at 0xFE106804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_1"
        group.long 0x2808--0x280B "BAM_P_PSM_CNTXT_2_1 (at 0xFE106808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_1"
        group.long 0x280C--0x280F "BAM_P_PSM_CNTXT_3_1 (at 0xFE10680C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_1"
        group.long 0x2810--0x2813 "BAM_P_PSM_CNTXT_4_1 (at 0xFE106810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_1"
        group.long 0x2814--0x2817 "BAM_P_PSM_CNTXT_5_1 (at 0xFE106814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 1
tree.end
tree "Pipe 2"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL2"
        group.long 0x3000--0x3003 "BAM_P_CTRL2 (at 0xFE107000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST2"
        group.long 0x3004--0x3007 "BAM_P_RST2 (at 0xFE107004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT2"
        group.long 0x3008--0x300B "BAM_P_HALT2 (at 0xFE107008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG2"
        group.long 0x3030--0x3033 "BAM_P_TRUST_REG2 (at 0xFE107030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS2"
        group.long 0x3010--0x3013 "BAM_P_IRQ_STTS2 (at 0xFE107010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR2"
        group.long 0x3014--0x3017 "BAM_P_IRQ_CLR2 (at 0xFE107014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN2"
        group.long 0x3018--0x301B "BAM_P_IRQ_EN2 (at 0xFE107018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER2"
        group.long 0x301C--0x301F "BAM_P_TIMER2 (at 0xFE10701C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL2"
        group.long 0x3020--0x3023 "BAM_P_TIMER_CTRL2 (at 0xFE107020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND2"
        group.long 0x3024--0x3027 "BAM_P_PRDCR_SDBND2 (at 0xFE107024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND2"
        group.long 0x3028--0x302B "BAM_P_CNSMR_SDBND2 (at 0xFE107028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR2"
        group.long 0x382C--0x382F "BAM_P_EVNT_DEST_ADDR2 (at 0xFE10782C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG2"
        group.long 0x3818--0x381B "BAM_P_EVNT_REG2 (at 0xFE107818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS2"
        group.long 0x3800--0x3803 "BAM_P_SW_OFSTS2 (at 0xFE107800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR2"
        group.long 0x3824--0x3827 "BAM_P_DATA_FIFO_ADDR2 (at 0xFE107824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR2"
        group.long 0x381C--0x381F "BAM_P_DESC_FIFO_ADDR2 (at 0xFE10781C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD2"
        group.long 0x3828--0x382B "BAM_P_EVNT_GEN_TRSHLD2 (at 0xFE107828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES2"
        group.long 0x3820--0x3823 "BAM_P_FIFO_SIZES2 (at 0xFE107820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_2"
        group.long 0x3834--0x3837 "BAM_P_RETR_CNTXT_2 (at 0xFE107834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_2"
        group.long 0x3838--0x383B "BAM_P_SI_CNTXT_2 (at 0xFE107838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_2"
        group.long 0x3830--0x3833 "BAM_P_DF_CNTXT_2 (at 0xFE107830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_2"
        group.long 0x3804--0x3807 "BAM_P_AU_PSM_CNTXT_1_2 (at 0xFE107804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_2"
        group.long 0x3808--0x380B "BAM_P_PSM_CNTXT_2_2 (at 0xFE107808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_2"
        group.long 0x380C--0x380F "BAM_P_PSM_CNTXT_3_2 (at 0xFE10780C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_2"
        group.long 0x3810--0x3813 "BAM_P_PSM_CNTXT_4_2 (at 0xFE107810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_2"
        group.long 0x3814--0x3817 "BAM_P_PSM_CNTXT_5_2 (at 0xFE107814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 2
tree.end
tree "Pipe 3"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL3"
        group.long 0x4000--0x4003 "BAM_P_CTRL3 (at 0xFE108000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST3"
        group.long 0x4004--0x4007 "BAM_P_RST3 (at 0xFE108004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT3"
        group.long 0x4008--0x400B "BAM_P_HALT3 (at 0xFE108008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG3"
        group.long 0x4030--0x4033 "BAM_P_TRUST_REG3 (at 0xFE108030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS3"
        group.long 0x4010--0x4013 "BAM_P_IRQ_STTS3 (at 0xFE108010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR3"
        group.long 0x4014--0x4017 "BAM_P_IRQ_CLR3 (at 0xFE108014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN3"
        group.long 0x4018--0x401B "BAM_P_IRQ_EN3 (at 0xFE108018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER3"
        group.long 0x401C--0x401F "BAM_P_TIMER3 (at 0xFE10801C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL3"
        group.long 0x4020--0x4023 "BAM_P_TIMER_CTRL3 (at 0xFE108020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND3"
        group.long 0x4024--0x4027 "BAM_P_PRDCR_SDBND3 (at 0xFE108024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND3"
        group.long 0x4028--0x402B "BAM_P_CNSMR_SDBND3 (at 0xFE108028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR3"
        group.long 0x482C--0x482F "BAM_P_EVNT_DEST_ADDR3 (at 0xFE10882C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG3"
        group.long 0x4818--0x481B "BAM_P_EVNT_REG3 (at 0xFE108818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS3"
        group.long 0x4800--0x4803 "BAM_P_SW_OFSTS3 (at 0xFE108800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR3"
        group.long 0x4824--0x4827 "BAM_P_DATA_FIFO_ADDR3 (at 0xFE108824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR3"
        group.long 0x481C--0x481F "BAM_P_DESC_FIFO_ADDR3 (at 0xFE10881C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD3"
        group.long 0x4828--0x482B "BAM_P_EVNT_GEN_TRSHLD3 (at 0xFE108828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES3"
        group.long 0x4820--0x4823 "BAM_P_FIFO_SIZES3 (at 0xFE108820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_3"
        group.long 0x4834--0x4837 "BAM_P_RETR_CNTXT_3 (at 0xFE108834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_3"
        group.long 0x4838--0x483B "BAM_P_SI_CNTXT_3 (at 0xFE108838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_3"
        group.long 0x4830--0x4833 "BAM_P_DF_CNTXT_3 (at 0xFE108830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_3"
        group.long 0x4804--0x4807 "BAM_P_AU_PSM_CNTXT_1_3 (at 0xFE108804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_3"
        group.long 0x4808--0x480B "BAM_P_PSM_CNTXT_2_3 (at 0xFE108808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_3"
        group.long 0x480C--0x480F "BAM_P_PSM_CNTXT_3_3 (at 0xFE10880C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_3"
        group.long 0x4810--0x4813 "BAM_P_PSM_CNTXT_4_3 (at 0xFE108810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_3"
        group.long 0x4814--0x4817 "BAM_P_PSM_CNTXT_5_3 (at 0xFE108814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 3
tree.end
tree "Pipe 4"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL4"
        group.long 0x5000--0x5003 "BAM_P_CTRL4 (at 0xFE109000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST4"
        group.long 0x5004--0x5007 "BAM_P_RST4 (at 0xFE109004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT4"
        group.long 0x5008--0x500B "BAM_P_HALT4 (at 0xFE109008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG4"
        group.long 0x5030--0x5033 "BAM_P_TRUST_REG4 (at 0xFE109030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS4"
        group.long 0x5010--0x5013 "BAM_P_IRQ_STTS4 (at 0xFE109010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR4"
        group.long 0x5014--0x5017 "BAM_P_IRQ_CLR4 (at 0xFE109014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN4"
        group.long 0x5018--0x501B "BAM_P_IRQ_EN4 (at 0xFE109018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER4"
        group.long 0x501C--0x501F "BAM_P_TIMER4 (at 0xFE10901C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL4"
        group.long 0x5020--0x5023 "BAM_P_TIMER_CTRL4 (at 0xFE109020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND4"
        group.long 0x5024--0x5027 "BAM_P_PRDCR_SDBND4 (at 0xFE109024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND4"
        group.long 0x5028--0x502B "BAM_P_CNSMR_SDBND4 (at 0xFE109028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR4"
        group.long 0x582C--0x582F "BAM_P_EVNT_DEST_ADDR4 (at 0xFE10982C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG4"
        group.long 0x5818--0x581B "BAM_P_EVNT_REG4 (at 0xFE109818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS4"
        group.long 0x5800--0x5803 "BAM_P_SW_OFSTS4 (at 0xFE109800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR4"
        group.long 0x5824--0x5827 "BAM_P_DATA_FIFO_ADDR4 (at 0xFE109824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR4"
        group.long 0x581C--0x581F "BAM_P_DESC_FIFO_ADDR4 (at 0xFE10981C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD4"
        group.long 0x5828--0x582B "BAM_P_EVNT_GEN_TRSHLD4 (at 0xFE109828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES4"
        group.long 0x5820--0x5823 "BAM_P_FIFO_SIZES4 (at 0xFE109820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_4"
        group.long 0x5834--0x5837 "BAM_P_RETR_CNTXT_4 (at 0xFE109834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_4"
        group.long 0x5838--0x583B "BAM_P_SI_CNTXT_4 (at 0xFE109838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_4"
        group.long 0x5830--0x5833 "BAM_P_DF_CNTXT_4 (at 0xFE109830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_4"
        group.long 0x5804--0x5807 "BAM_P_AU_PSM_CNTXT_1_4 (at 0xFE109804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_4"
        group.long 0x5808--0x580B "BAM_P_PSM_CNTXT_2_4 (at 0xFE109808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_4"
        group.long 0x580C--0x580F "BAM_P_PSM_CNTXT_3_4 (at 0xFE10980C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_4"
        group.long 0x5810--0x5813 "BAM_P_PSM_CNTXT_4_4 (at 0xFE109810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_4"
        group.long 0x5814--0x5817 "BAM_P_PSM_CNTXT_5_4 (at 0xFE109814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 4
tree.end
tree "Pipe 5"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL5"
        group.long 0x6000--0x6003 "BAM_P_CTRL5 (at 0xFE10A000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST5"
        group.long 0x6004--0x6007 "BAM_P_RST5 (at 0xFE10A004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT5"
        group.long 0x6008--0x600B "BAM_P_HALT5 (at 0xFE10A008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG5"
        group.long 0x6030--0x6033 "BAM_P_TRUST_REG5 (at 0xFE10A030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS5"
        group.long 0x6010--0x6013 "BAM_P_IRQ_STTS5 (at 0xFE10A010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR5"
        group.long 0x6014--0x6017 "BAM_P_IRQ_CLR5 (at 0xFE10A014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN5"
        group.long 0x6018--0x601B "BAM_P_IRQ_EN5 (at 0xFE10A018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER5"
        group.long 0x601C--0x601F "BAM_P_TIMER5 (at 0xFE10A01C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL5"
        group.long 0x6020--0x6023 "BAM_P_TIMER_CTRL5 (at 0xFE10A020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND5"
        group.long 0x6024--0x6027 "BAM_P_PRDCR_SDBND5 (at 0xFE10A024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND5"
        group.long 0x6028--0x602B "BAM_P_CNSMR_SDBND5 (at 0xFE10A028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR5"
        group.long 0x682C--0x682F "BAM_P_EVNT_DEST_ADDR5 (at 0xFE10A82C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG5"
        group.long 0x6818--0x681B "BAM_P_EVNT_REG5 (at 0xFE10A818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS5"
        group.long 0x6800--0x6803 "BAM_P_SW_OFSTS5 (at 0xFE10A800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR5"
        group.long 0x6824--0x6827 "BAM_P_DATA_FIFO_ADDR5 (at 0xFE10A824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR5"
        group.long 0x681C--0x681F "BAM_P_DESC_FIFO_ADDR5 (at 0xFE10A81C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD5"
        group.long 0x6828--0x682B "BAM_P_EVNT_GEN_TRSHLD5 (at 0xFE10A828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES5"
        group.long 0x6820--0x6823 "BAM_P_FIFO_SIZES5 (at 0xFE10A820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_5"
        group.long 0x6834--0x6837 "BAM_P_RETR_CNTXT_5 (at 0xFE10A834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_5"
        group.long 0x6838--0x683B "BAM_P_SI_CNTXT_5 (at 0xFE10A838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_5"
        group.long 0x6830--0x6833 "BAM_P_DF_CNTXT_5 (at 0xFE10A830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_5"
        group.long 0x6804--0x6807 "BAM_P_AU_PSM_CNTXT_1_5 (at 0xFE10A804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_5"
        group.long 0x6808--0x680B "BAM_P_PSM_CNTXT_2_5 (at 0xFE10A808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_5"
        group.long 0x680C--0x680F "BAM_P_PSM_CNTXT_3_5 (at 0xFE10A80C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_5"
        group.long 0x6810--0x6813 "BAM_P_PSM_CNTXT_4_5 (at 0xFE10A810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_5"
        group.long 0x6814--0x6817 "BAM_P_PSM_CNTXT_5_5 (at 0xFE10A814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 5
tree.end
tree "Pipe 6"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL6"
        group.long 0x7000--0x7003 "BAM_P_CTRL6 (at 0xFE10B000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST6"
        group.long 0x7004--0x7007 "BAM_P_RST6 (at 0xFE10B004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT6"
        group.long 0x7008--0x700B "BAM_P_HALT6 (at 0xFE10B008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG6"
        group.long 0x7030--0x7033 "BAM_P_TRUST_REG6 (at 0xFE10B030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS6"
        group.long 0x7010--0x7013 "BAM_P_IRQ_STTS6 (at 0xFE10B010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR6"
        group.long 0x7014--0x7017 "BAM_P_IRQ_CLR6 (at 0xFE10B014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN6"
        group.long 0x7018--0x701B "BAM_P_IRQ_EN6 (at 0xFE10B018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER6"
        group.long 0x701C--0x701F "BAM_P_TIMER6 (at 0xFE10B01C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL6"
        group.long 0x7020--0x7023 "BAM_P_TIMER_CTRL6 (at 0xFE10B020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND6"
        group.long 0x7024--0x7027 "BAM_P_PRDCR_SDBND6 (at 0xFE10B024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND6"
        group.long 0x7028--0x702B "BAM_P_CNSMR_SDBND6 (at 0xFE10B028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR6"
        group.long 0x782C--0x782F "BAM_P_EVNT_DEST_ADDR6 (at 0xFE10B82C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG6"
        group.long 0x7818--0x781B "BAM_P_EVNT_REG6 (at 0xFE10B818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS6"
        group.long 0x7800--0x7803 "BAM_P_SW_OFSTS6 (at 0xFE10B800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR6"
        group.long 0x7824--0x7827 "BAM_P_DATA_FIFO_ADDR6 (at 0xFE10B824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR6"
        group.long 0x781C--0x781F "BAM_P_DESC_FIFO_ADDR6 (at 0xFE10B81C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD6"
        group.long 0x7828--0x782B "BAM_P_EVNT_GEN_TRSHLD6 (at 0xFE10B828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES6"
        group.long 0x7820--0x7823 "BAM_P_FIFO_SIZES6 (at 0xFE10B820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_6"
        group.long 0x7834--0x7837 "BAM_P_RETR_CNTXT_6 (at 0xFE10B834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_6"
        group.long 0x7838--0x783B "BAM_P_SI_CNTXT_6 (at 0xFE10B838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_6"
        group.long 0x7830--0x7833 "BAM_P_DF_CNTXT_6 (at 0xFE10B830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_6"
        group.long 0x7804--0x7807 "BAM_P_AU_PSM_CNTXT_1_6 (at 0xFE10B804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_6"
        group.long 0x7808--0x780B "BAM_P_PSM_CNTXT_2_6 (at 0xFE10B808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_6"
        group.long 0x780C--0x780F "BAM_P_PSM_CNTXT_3_6 (at 0xFE10B80C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_6"
        group.long 0x7810--0x7813 "BAM_P_PSM_CNTXT_4_6 (at 0xFE10B810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_6"
        group.long 0x7814--0x7817 "BAM_P_PSM_CNTXT_5_6 (at 0xFE10B814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 6
tree.end
tree "Pipe 7"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL7"
        group.long 0x8000--0x8003 "BAM_P_CTRL7 (at 0xFE10C000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST7"
        group.long 0x8004--0x8007 "BAM_P_RST7 (at 0xFE10C004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT7"
        group.long 0x8008--0x800B "BAM_P_HALT7 (at 0xFE10C008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG7"
        group.long 0x8030--0x8033 "BAM_P_TRUST_REG7 (at 0xFE10C030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS7"
        group.long 0x8010--0x8013 "BAM_P_IRQ_STTS7 (at 0xFE10C010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR7"
        group.long 0x8014--0x8017 "BAM_P_IRQ_CLR7 (at 0xFE10C014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN7"
        group.long 0x8018--0x801B "BAM_P_IRQ_EN7 (at 0xFE10C018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER7"
        group.long 0x801C--0x801F "BAM_P_TIMER7 (at 0xFE10C01C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL7"
        group.long 0x8020--0x8023 "BAM_P_TIMER_CTRL7 (at 0xFE10C020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND7"
        group.long 0x8024--0x8027 "BAM_P_PRDCR_SDBND7 (at 0xFE10C024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND7"
        group.long 0x8028--0x802B "BAM_P_CNSMR_SDBND7 (at 0xFE10C028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR7"
        group.long 0x882C--0x882F "BAM_P_EVNT_DEST_ADDR7 (at 0xFE10C82C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG7"
        group.long 0x8818--0x881B "BAM_P_EVNT_REG7 (at 0xFE10C818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS7"
        group.long 0x8800--0x8803 "BAM_P_SW_OFSTS7 (at 0xFE10C800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR7"
        group.long 0x8824--0x8827 "BAM_P_DATA_FIFO_ADDR7 (at 0xFE10C824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR7"
        group.long 0x881C--0x881F "BAM_P_DESC_FIFO_ADDR7 (at 0xFE10C81C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD7"
        group.long 0x8828--0x882B "BAM_P_EVNT_GEN_TRSHLD7 (at 0xFE10C828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES7"
        group.long 0x8820--0x8823 "BAM_P_FIFO_SIZES7 (at 0xFE10C820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_7"
        group.long 0x8834--0x8837 "BAM_P_RETR_CNTXT_7 (at 0xFE10C834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_7"
        group.long 0x8838--0x883B "BAM_P_SI_CNTXT_7 (at 0xFE10C838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_7"
        group.long 0x8830--0x8833 "BAM_P_DF_CNTXT_7 (at 0xFE10C830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_7"
        group.long 0x8804--0x8807 "BAM_P_AU_PSM_CNTXT_1_7 (at 0xFE10C804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_7"
        group.long 0x8808--0x880B "BAM_P_PSM_CNTXT_2_7 (at 0xFE10C808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_7"
        group.long 0x880C--0x880F "BAM_P_PSM_CNTXT_3_7 (at 0xFE10C80C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_7"
        group.long 0x8810--0x8813 "BAM_P_PSM_CNTXT_4_7 (at 0xFE10C810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_7"
        group.long 0x8814--0x8817 "BAM_P_PSM_CNTXT_5_7 (at 0xFE10C814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 7
tree.end
tree "Pipe 8"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL8"
        group.long 0x9000--0x9003 "BAM_P_CTRL8 (at 0xFE10D000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST8"
        group.long 0x9004--0x9007 "BAM_P_RST8 (at 0xFE10D004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT8"
        group.long 0x9008--0x900B "BAM_P_HALT8 (at 0xFE10D008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG8"
        group.long 0x9030--0x9033 "BAM_P_TRUST_REG8 (at 0xFE10D030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS8"
        group.long 0x9010--0x9013 "BAM_P_IRQ_STTS8 (at 0xFE10D010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR8"
        group.long 0x9014--0x9017 "BAM_P_IRQ_CLR8 (at 0xFE10D014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN8"
        group.long 0x9018--0x901B "BAM_P_IRQ_EN8 (at 0xFE10D018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER8"
        group.long 0x901C--0x901F "BAM_P_TIMER8 (at 0xFE10D01C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL8"
        group.long 0x9020--0x9023 "BAM_P_TIMER_CTRL8 (at 0xFE10D020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND8"
        group.long 0x9024--0x9027 "BAM_P_PRDCR_SDBND8 (at 0xFE10D024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND8"
        group.long 0x9028--0x902B "BAM_P_CNSMR_SDBND8 (at 0xFE10D028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR8"
        group.long 0x982C--0x982F "BAM_P_EVNT_DEST_ADDR8 (at 0xFE10D82C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG8"
        group.long 0x9818--0x981B "BAM_P_EVNT_REG8 (at 0xFE10D818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS8"
        group.long 0x9800--0x9803 "BAM_P_SW_OFSTS8 (at 0xFE10D800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR8"
        group.long 0x9824--0x9827 "BAM_P_DATA_FIFO_ADDR8 (at 0xFE10D824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR8"
        group.long 0x981C--0x981F "BAM_P_DESC_FIFO_ADDR8 (at 0xFE10D81C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD8"
        group.long 0x9828--0x982B "BAM_P_EVNT_GEN_TRSHLD8 (at 0xFE10D828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES8"
        group.long 0x9820--0x9823 "BAM_P_FIFO_SIZES8 (at 0xFE10D820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_8"
        group.long 0x9834--0x9837 "BAM_P_RETR_CNTXT_8 (at 0xFE10D834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_8"
        group.long 0x9838--0x983B "BAM_P_SI_CNTXT_8 (at 0xFE10D838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_8"
        group.long 0x9830--0x9833 "BAM_P_DF_CNTXT_8 (at 0xFE10D830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_8"
        group.long 0x9804--0x9807 "BAM_P_AU_PSM_CNTXT_1_8 (at 0xFE10D804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_8"
        group.long 0x9808--0x980B "BAM_P_PSM_CNTXT_2_8 (at 0xFE10D808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_8"
        group.long 0x980C--0x980F "BAM_P_PSM_CNTXT_3_8 (at 0xFE10D80C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_8"
        group.long 0x9810--0x9813 "BAM_P_PSM_CNTXT_4_8 (at 0xFE10D810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_8"
        group.long 0x9814--0x9817 "BAM_P_PSM_CNTXT_5_8 (at 0xFE10D814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 8
tree.end
tree "Pipe 9"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL9"
        group.long 0xA000--0xA003 "BAM_P_CTRL9 (at 0xFE10E000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST9"
        group.long 0xA004--0xA007 "BAM_P_RST9 (at 0xFE10E004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT9"
        group.long 0xA008--0xA00B "BAM_P_HALT9 (at 0xFE10E008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG9"
        group.long 0xA030--0xA033 "BAM_P_TRUST_REG9 (at 0xFE10E030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS9"
        group.long 0xA010--0xA013 "BAM_P_IRQ_STTS9 (at 0xFE10E010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR9"
        group.long 0xA014--0xA017 "BAM_P_IRQ_CLR9 (at 0xFE10E014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN9"
        group.long 0xA018--0xA01B "BAM_P_IRQ_EN9 (at 0xFE10E018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER9"
        group.long 0xA01C--0xA01F "BAM_P_TIMER9 (at 0xFE10E01C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL9"
        group.long 0xA020--0xA023 "BAM_P_TIMER_CTRL9 (at 0xFE10E020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND9"
        group.long 0xA024--0xA027 "BAM_P_PRDCR_SDBND9 (at 0xFE10E024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND9"
        group.long 0xA028--0xA02B "BAM_P_CNSMR_SDBND9 (at 0xFE10E028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR9"
        group.long 0xA82C--0xA82F "BAM_P_EVNT_DEST_ADDR9 (at 0xFE10E82C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG9"
        group.long 0xA818--0xA81B "BAM_P_EVNT_REG9 (at 0xFE10E818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS9"
        group.long 0xA800--0xA803 "BAM_P_SW_OFSTS9 (at 0xFE10E800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR9"
        group.long 0xA824--0xA827 "BAM_P_DATA_FIFO_ADDR9 (at 0xFE10E824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR9"
        group.long 0xA81C--0xA81F "BAM_P_DESC_FIFO_ADDR9 (at 0xFE10E81C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD9"
        group.long 0xA828--0xA82B "BAM_P_EVNT_GEN_TRSHLD9 (at 0xFE10E828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES9"
        group.long 0xA820--0xA823 "BAM_P_FIFO_SIZES9 (at 0xFE10E820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_9"
        group.long 0xA834--0xA837 "BAM_P_RETR_CNTXT_9 (at 0xFE10E834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_9"
        group.long 0xA838--0xA83B "BAM_P_SI_CNTXT_9 (at 0xFE10E838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_9"
        group.long 0xA830--0xA833 "BAM_P_DF_CNTXT_9 (at 0xFE10E830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_9"
        group.long 0xA804--0xA807 "BAM_P_AU_PSM_CNTXT_1_9 (at 0xFE10E804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_9"
        group.long 0xA808--0xA80B "BAM_P_PSM_CNTXT_2_9 (at 0xFE10E808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_9"
        group.long 0xA80C--0xA80F "BAM_P_PSM_CNTXT_3_9 (at 0xFE10E80C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_9"
        group.long 0xA810--0xA813 "BAM_P_PSM_CNTXT_4_9 (at 0xFE10E810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_9"
        group.long 0xA814--0xA817 "BAM_P_PSM_CNTXT_5_9 (at 0xFE10E814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 9
tree.end
tree "Pipe 10"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL10"
        group.long 0xB000--0xB003 "BAM_P_CTRL10 (at 0xFE10F000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST10"
        group.long 0xB004--0xB007 "BAM_P_RST10 (at 0xFE10F004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT10"
        group.long 0xB008--0xB00B "BAM_P_HALT10 (at 0xFE10F008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG10"
        group.long 0xB030--0xB033 "BAM_P_TRUST_REG10 (at 0xFE10F030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS10"
        group.long 0xB010--0xB013 "BAM_P_IRQ_STTS10 (at 0xFE10F010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR10"
        group.long 0xB014--0xB017 "BAM_P_IRQ_CLR10 (at 0xFE10F014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN10"
        group.long 0xB018--0xB01B "BAM_P_IRQ_EN10 (at 0xFE10F018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER10"
        group.long 0xB01C--0xB01F "BAM_P_TIMER10 (at 0xFE10F01C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL10"
        group.long 0xB020--0xB023 "BAM_P_TIMER_CTRL10 (at 0xFE10F020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND10"
        group.long 0xB024--0xB027 "BAM_P_PRDCR_SDBND10 (at 0xFE10F024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND10"
        group.long 0xB028--0xB02B "BAM_P_CNSMR_SDBND10 (at 0xFE10F028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR10"
        group.long 0xB82C--0xB82F "BAM_P_EVNT_DEST_ADDR10 (at 0xFE10F82C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG10"
        group.long 0xB818--0xB81B "BAM_P_EVNT_REG10 (at 0xFE10F818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS10"
        group.long 0xB800--0xB803 "BAM_P_SW_OFSTS10 (at 0xFE10F800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR10"
        group.long 0xB824--0xB827 "BAM_P_DATA_FIFO_ADDR10 (at 0xFE10F824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR10"
        group.long 0xB81C--0xB81F "BAM_P_DESC_FIFO_ADDR10 (at 0xFE10F81C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD10"
        group.long 0xB828--0xB82B "BAM_P_EVNT_GEN_TRSHLD10 (at 0xFE10F828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES10"
        group.long 0xB820--0xB823 "BAM_P_FIFO_SIZES10 (at 0xFE10F820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_10"
        group.long 0xB834--0xB837 "BAM_P_RETR_CNTXT_10 (at 0xFE10F834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_10"
        group.long 0xB838--0xB83B "BAM_P_SI_CNTXT_10 (at 0xFE10F838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_10"
        group.long 0xB830--0xB833 "BAM_P_DF_CNTXT_10 (at 0xFE10F830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_10"
        group.long 0xB804--0xB807 "BAM_P_AU_PSM_CNTXT_1_10 (at 0xFE10F804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_10"
        group.long 0xB808--0xB80B "BAM_P_PSM_CNTXT_2_10 (at 0xFE10F808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_10"
        group.long 0xB80C--0xB80F "BAM_P_PSM_CNTXT_3_10 (at 0xFE10F80C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_10"
        group.long 0xB810--0xB813 "BAM_P_PSM_CNTXT_4_10 (at 0xFE10F810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_10"
        group.long 0xB814--0xB817 "BAM_P_PSM_CNTXT_5_10 (at 0xFE10F814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 10
tree.end
tree "Pipe 11"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL11"
        group.long 0xC000--0xC003 "BAM_P_CTRL11 (at 0xFE110000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST11"
        group.long 0xC004--0xC007 "BAM_P_RST11 (at 0xFE110004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT11"
        group.long 0xC008--0xC00B "BAM_P_HALT11 (at 0xFE110008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG11"
        group.long 0xC030--0xC033 "BAM_P_TRUST_REG11 (at 0xFE110030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS11"
        group.long 0xC010--0xC013 "BAM_P_IRQ_STTS11 (at 0xFE110010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR11"
        group.long 0xC014--0xC017 "BAM_P_IRQ_CLR11 (at 0xFE110014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN11"
        group.long 0xC018--0xC01B "BAM_P_IRQ_EN11 (at 0xFE110018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER11"
        group.long 0xC01C--0xC01F "BAM_P_TIMER11 (at 0xFE11001C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL11"
        group.long 0xC020--0xC023 "BAM_P_TIMER_CTRL11 (at 0xFE110020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND11"
        group.long 0xC024--0xC027 "BAM_P_PRDCR_SDBND11 (at 0xFE110024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND11"
        group.long 0xC028--0xC02B "BAM_P_CNSMR_SDBND11 (at 0xFE110028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR11"
        group.long 0xC82C--0xC82F "BAM_P_EVNT_DEST_ADDR11 (at 0xFE11082C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG11"
        group.long 0xC818--0xC81B "BAM_P_EVNT_REG11 (at 0xFE110818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS11"
        group.long 0xC800--0xC803 "BAM_P_SW_OFSTS11 (at 0xFE110800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR11"
        group.long 0xC824--0xC827 "BAM_P_DATA_FIFO_ADDR11 (at 0xFE110824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR11"
        group.long 0xC81C--0xC81F "BAM_P_DESC_FIFO_ADDR11 (at 0xFE11081C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD11"
        group.long 0xC828--0xC82B "BAM_P_EVNT_GEN_TRSHLD11 (at 0xFE110828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES11"
        group.long 0xC820--0xC823 "BAM_P_FIFO_SIZES11 (at 0xFE110820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_11"
        group.long 0xC834--0xC837 "BAM_P_RETR_CNTXT_11 (at 0xFE110834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_11"
        group.long 0xC838--0xC83B "BAM_P_SI_CNTXT_11 (at 0xFE110838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_11"
        group.long 0xC830--0xC833 "BAM_P_DF_CNTXT_11 (at 0xFE110830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_11"
        group.long 0xC804--0xC807 "BAM_P_AU_PSM_CNTXT_1_11 (at 0xFE110804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_11"
        group.long 0xC808--0xC80B "BAM_P_PSM_CNTXT_2_11 (at 0xFE110808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_11"
        group.long 0xC80C--0xC80F "BAM_P_PSM_CNTXT_3_11 (at 0xFE11080C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_11"
        group.long 0xC810--0xC813 "BAM_P_PSM_CNTXT_4_11 (at 0xFE110810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_11"
        group.long 0xC814--0xC817 "BAM_P_PSM_CNTXT_5_11 (at 0xFE110814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 11
tree.end
tree "Pipe 12"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL12"
        group.long 0xD000--0xD003 "BAM_P_CTRL12 (at 0xFE111000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST12"
        group.long 0xD004--0xD007 "BAM_P_RST12 (at 0xFE111004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT12"
        group.long 0xD008--0xD00B "BAM_P_HALT12 (at 0xFE111008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG12"
        group.long 0xD030--0xD033 "BAM_P_TRUST_REG12 (at 0xFE111030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS12"
        group.long 0xD010--0xD013 "BAM_P_IRQ_STTS12 (at 0xFE111010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR12"
        group.long 0xD014--0xD017 "BAM_P_IRQ_CLR12 (at 0xFE111014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN12"
        group.long 0xD018--0xD01B "BAM_P_IRQ_EN12 (at 0xFE111018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER12"
        group.long 0xD01C--0xD01F "BAM_P_TIMER12 (at 0xFE11101C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL12"
        group.long 0xD020--0xD023 "BAM_P_TIMER_CTRL12 (at 0xFE111020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND12"
        group.long 0xD024--0xD027 "BAM_P_PRDCR_SDBND12 (at 0xFE111024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND12"
        group.long 0xD028--0xD02B "BAM_P_CNSMR_SDBND12 (at 0xFE111028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR12"
        group.long 0xD82C--0xD82F "BAM_P_EVNT_DEST_ADDR12 (at 0xFE11182C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG12"
        group.long 0xD818--0xD81B "BAM_P_EVNT_REG12 (at 0xFE111818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS12"
        group.long 0xD800--0xD803 "BAM_P_SW_OFSTS12 (at 0xFE111800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR12"
        group.long 0xD824--0xD827 "BAM_P_DATA_FIFO_ADDR12 (at 0xFE111824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR12"
        group.long 0xD81C--0xD81F "BAM_P_DESC_FIFO_ADDR12 (at 0xFE11181C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD12"
        group.long 0xD828--0xD82B "BAM_P_EVNT_GEN_TRSHLD12 (at 0xFE111828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES12"
        group.long 0xD820--0xD823 "BAM_P_FIFO_SIZES12 (at 0xFE111820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_12"
        group.long 0xD834--0xD837 "BAM_P_RETR_CNTXT_12 (at 0xFE111834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_12"
        group.long 0xD838--0xD83B "BAM_P_SI_CNTXT_12 (at 0xFE111838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_12"
        group.long 0xD830--0xD833 "BAM_P_DF_CNTXT_12 (at 0xFE111830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_12"
        group.long 0xD804--0xD807 "BAM_P_AU_PSM_CNTXT_1_12 (at 0xFE111804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_12"
        group.long 0xD808--0xD80B "BAM_P_PSM_CNTXT_2_12 (at 0xFE111808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_12"
        group.long 0xD80C--0xD80F "BAM_P_PSM_CNTXT_3_12 (at 0xFE11180C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_12"
        group.long 0xD810--0xD813 "BAM_P_PSM_CNTXT_4_12 (at 0xFE111810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_12"
        group.long 0xD814--0xD817 "BAM_P_PSM_CNTXT_5_12 (at 0xFE111814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 12
tree.end
tree "Pipe 13"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL13"
        group.long 0xE000--0xE003 "BAM_P_CTRL13 (at 0xFE112000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST13"
        group.long 0xE004--0xE007 "BAM_P_RST13 (at 0xFE112004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT13"
        group.long 0xE008--0xE00B "BAM_P_HALT13 (at 0xFE112008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG13"
        group.long 0xE030--0xE033 "BAM_P_TRUST_REG13 (at 0xFE112030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS13"
        group.long 0xE010--0xE013 "BAM_P_IRQ_STTS13 (at 0xFE112010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR13"
        group.long 0xE014--0xE017 "BAM_P_IRQ_CLR13 (at 0xFE112014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN13"
        group.long 0xE018--0xE01B "BAM_P_IRQ_EN13 (at 0xFE112018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER13"
        group.long 0xE01C--0xE01F "BAM_P_TIMER13 (at 0xFE11201C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL13"
        group.long 0xE020--0xE023 "BAM_P_TIMER_CTRL13 (at 0xFE112020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND13"
        group.long 0xE024--0xE027 "BAM_P_PRDCR_SDBND13 (at 0xFE112024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND13"
        group.long 0xE028--0xE02B "BAM_P_CNSMR_SDBND13 (at 0xFE112028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR13"
        group.long 0xE82C--0xE82F "BAM_P_EVNT_DEST_ADDR13 (at 0xFE11282C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG13"
        group.long 0xE818--0xE81B "BAM_P_EVNT_REG13 (at 0xFE112818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS13"
        group.long 0xE800--0xE803 "BAM_P_SW_OFSTS13 (at 0xFE112800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR13"
        group.long 0xE824--0xE827 "BAM_P_DATA_FIFO_ADDR13 (at 0xFE112824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR13"
        group.long 0xE81C--0xE81F "BAM_P_DESC_FIFO_ADDR13 (at 0xFE11281C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD13"
        group.long 0xE828--0xE82B "BAM_P_EVNT_GEN_TRSHLD13 (at 0xFE112828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES13"
        group.long 0xE820--0xE823 "BAM_P_FIFO_SIZES13 (at 0xFE112820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_13"
        group.long 0xE834--0xE837 "BAM_P_RETR_CNTXT_13 (at 0xFE112834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_13"
        group.long 0xE838--0xE83B "BAM_P_SI_CNTXT_13 (at 0xFE112838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_13"
        group.long 0xE830--0xE833 "BAM_P_DF_CNTXT_13 (at 0xFE112830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_13"
        group.long 0xE804--0xE807 "BAM_P_AU_PSM_CNTXT_1_13 (at 0xFE112804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_13"
        group.long 0xE808--0xE80B "BAM_P_PSM_CNTXT_2_13 (at 0xFE112808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_13"
        group.long 0xE80C--0xE80F "BAM_P_PSM_CNTXT_3_13 (at 0xFE11280C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_13"
        group.long 0xE810--0xE813 "BAM_P_PSM_CNTXT_4_13 (at 0xFE112810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_13"
        group.long 0xE814--0xE817 "BAM_P_PSM_CNTXT_5_13 (at 0xFE112814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 13
tree.end
tree "Pipe 14"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL14"
        group.long 0xF000--0xF003 "BAM_P_CTRL14 (at 0xFE113000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST14"
        group.long 0xF004--0xF007 "BAM_P_RST14 (at 0xFE113004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT14"
        group.long 0xF008--0xF00B "BAM_P_HALT14 (at 0xFE113008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG14"
        group.long 0xF030--0xF033 "BAM_P_TRUST_REG14 (at 0xFE113030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS14"
        group.long 0xF010--0xF013 "BAM_P_IRQ_STTS14 (at 0xFE113010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR14"
        group.long 0xF014--0xF017 "BAM_P_IRQ_CLR14 (at 0xFE113014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN14"
        group.long 0xF018--0xF01B "BAM_P_IRQ_EN14 (at 0xFE113018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER14"
        group.long 0xF01C--0xF01F "BAM_P_TIMER14 (at 0xFE11301C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL14"
        group.long 0xF020--0xF023 "BAM_P_TIMER_CTRL14 (at 0xFE113020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND14"
        group.long 0xF024--0xF027 "BAM_P_PRDCR_SDBND14 (at 0xFE113024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND14"
        group.long 0xF028--0xF02B "BAM_P_CNSMR_SDBND14 (at 0xFE113028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR14"
        group.long 0xF82C--0xF82F "BAM_P_EVNT_DEST_ADDR14 (at 0xFE11382C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG14"
        group.long 0xF818--0xF81B "BAM_P_EVNT_REG14 (at 0xFE113818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS14"
        group.long 0xF800--0xF803 "BAM_P_SW_OFSTS14 (at 0xFE113800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR14"
        group.long 0xF824--0xF827 "BAM_P_DATA_FIFO_ADDR14 (at 0xFE113824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR14"
        group.long 0xF81C--0xF81F "BAM_P_DESC_FIFO_ADDR14 (at 0xFE11381C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD14"
        group.long 0xF828--0xF82B "BAM_P_EVNT_GEN_TRSHLD14 (at 0xFE113828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES14"
        group.long 0xF820--0xF823 "BAM_P_FIFO_SIZES14 (at 0xFE113820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_14"
        group.long 0xF834--0xF837 "BAM_P_RETR_CNTXT_14 (at 0xFE113834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_14"
        group.long 0xF838--0xF83B "BAM_P_SI_CNTXT_14 (at 0xFE113838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_14"
        group.long 0xF830--0xF833 "BAM_P_DF_CNTXT_14 (at 0xFE113830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_14"
        group.long 0xF804--0xF807 "BAM_P_AU_PSM_CNTXT_1_14 (at 0xFE113804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_14"
        group.long 0xF808--0xF80B "BAM_P_PSM_CNTXT_2_14 (at 0xFE113808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_14"
        group.long 0xF80C--0xF80F "BAM_P_PSM_CNTXT_3_14 (at 0xFE11380C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_14"
        group.long 0xF810--0xF813 "BAM_P_PSM_CNTXT_4_14 (at 0xFE113810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_14"
        group.long 0xF814--0xF817 "BAM_P_PSM_CNTXT_5_14 (at 0xFE113814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 14
tree.end
tree "Pipe 15"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL15"
        group.long 0x10000--0x10003 "BAM_P_CTRL15 (at 0xFE114000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST15"
        group.long 0x10004--0x10007 "BAM_P_RST15 (at 0xFE114004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT15"
        group.long 0x10008--0x1000B "BAM_P_HALT15 (at 0xFE114008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG15"
        group.long 0x10030--0x10033 "BAM_P_TRUST_REG15 (at 0xFE114030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS15"
        group.long 0x10010--0x10013 "BAM_P_IRQ_STTS15 (at 0xFE114010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR15"
        group.long 0x10014--0x10017 "BAM_P_IRQ_CLR15 (at 0xFE114014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN15"
        group.long 0x10018--0x1001B "BAM_P_IRQ_EN15 (at 0xFE114018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER15"
        group.long 0x1001C--0x1001F "BAM_P_TIMER15 (at 0xFE11401C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL15"
        group.long 0x10020--0x10023 "BAM_P_TIMER_CTRL15 (at 0xFE114020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND15"
        group.long 0x10024--0x10027 "BAM_P_PRDCR_SDBND15 (at 0xFE114024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND15"
        group.long 0x10028--0x1002B "BAM_P_CNSMR_SDBND15 (at 0xFE114028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR15"
        group.long 0x1082C--0x1082F "BAM_P_EVNT_DEST_ADDR15 (at 0xFE11482C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG15"
        group.long 0x10818--0x1081B "BAM_P_EVNT_REG15 (at 0xFE114818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS15"
        group.long 0x10800--0x10803 "BAM_P_SW_OFSTS15 (at 0xFE114800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR15"
        group.long 0x10824--0x10827 "BAM_P_DATA_FIFO_ADDR15 (at 0xFE114824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR15"
        group.long 0x1081C--0x1081F "BAM_P_DESC_FIFO_ADDR15 (at 0xFE11481C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD15"
        group.long 0x10828--0x1082B "BAM_P_EVNT_GEN_TRSHLD15 (at 0xFE114828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES15"
        group.long 0x10820--0x10823 "BAM_P_FIFO_SIZES15 (at 0xFE114820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_15"
        group.long 0x10834--0x10837 "BAM_P_RETR_CNTXT_15 (at 0xFE114834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_15"
        group.long 0x10838--0x1083B "BAM_P_SI_CNTXT_15 (at 0xFE114838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_15"
        group.long 0x10830--0x10833 "BAM_P_DF_CNTXT_15 (at 0xFE114830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_15"
        group.long 0x10804--0x10807 "BAM_P_AU_PSM_CNTXT_1_15 (at 0xFE114804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_15"
        group.long 0x10808--0x1080B "BAM_P_PSM_CNTXT_2_15 (at 0xFE114808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_15"
        group.long 0x1080C--0x1080F "BAM_P_PSM_CNTXT_3_15 (at 0xFE11480C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_15"
        group.long 0x10810--0x10813 "BAM_P_PSM_CNTXT_4_15 (at 0xFE114810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_15"
        group.long 0x10814--0x10817 "BAM_P_PSM_CNTXT_5_15 (at 0xFE114814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 15
tree.end
tree "Pipe 16"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL16"
        group.long 0x11000--0x11003 "BAM_P_CTRL16 (at 0xFE115000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST16"
        group.long 0x11004--0x11007 "BAM_P_RST16 (at 0xFE115004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT16"
        group.long 0x11008--0x1100B "BAM_P_HALT16 (at 0xFE115008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG16"
        group.long 0x11030--0x11033 "BAM_P_TRUST_REG16 (at 0xFE115030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS16"
        group.long 0x11010--0x11013 "BAM_P_IRQ_STTS16 (at 0xFE115010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR16"
        group.long 0x11014--0x11017 "BAM_P_IRQ_CLR16 (at 0xFE115014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN16"
        group.long 0x11018--0x1101B "BAM_P_IRQ_EN16 (at 0xFE115018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER16"
        group.long 0x1101C--0x1101F "BAM_P_TIMER16 (at 0xFE11501C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL16"
        group.long 0x11020--0x11023 "BAM_P_TIMER_CTRL16 (at 0xFE115020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND16"
        group.long 0x11024--0x11027 "BAM_P_PRDCR_SDBND16 (at 0xFE115024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND16"
        group.long 0x11028--0x1102B "BAM_P_CNSMR_SDBND16 (at 0xFE115028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR16"
        group.long 0x1182C--0x1182F "BAM_P_EVNT_DEST_ADDR16 (at 0xFE11582C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG16"
        group.long 0x11818--0x1181B "BAM_P_EVNT_REG16 (at 0xFE115818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS16"
        group.long 0x11800--0x11803 "BAM_P_SW_OFSTS16 (at 0xFE115800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR16"
        group.long 0x11824--0x11827 "BAM_P_DATA_FIFO_ADDR16 (at 0xFE115824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR16"
        group.long 0x1181C--0x1181F "BAM_P_DESC_FIFO_ADDR16 (at 0xFE11581C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD16"
        group.long 0x11828--0x1182B "BAM_P_EVNT_GEN_TRSHLD16 (at 0xFE115828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES16"
        group.long 0x11820--0x11823 "BAM_P_FIFO_SIZES16 (at 0xFE115820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_16"
        group.long 0x11834--0x11837 "BAM_P_RETR_CNTXT_16 (at 0xFE115834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_16"
        group.long 0x11838--0x1183B "BAM_P_SI_CNTXT_16 (at 0xFE115838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_16"
        group.long 0x11830--0x11833 "BAM_P_DF_CNTXT_16 (at 0xFE115830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_16"
        group.long 0x11804--0x11807 "BAM_P_AU_PSM_CNTXT_1_16 (at 0xFE115804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_16"
        group.long 0x11808--0x1180B "BAM_P_PSM_CNTXT_2_16 (at 0xFE115808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_16"
        group.long 0x1180C--0x1180F "BAM_P_PSM_CNTXT_3_16 (at 0xFE11580C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_16"
        group.long 0x11810--0x11813 "BAM_P_PSM_CNTXT_4_16 (at 0xFE115810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_16"
        group.long 0x11814--0x11817 "BAM_P_PSM_CNTXT_5_16 (at 0xFE115814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 16
tree.end
tree "Pipe 17"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL17"
        group.long 0x12000--0x12003 "BAM_P_CTRL17 (at 0xFE116000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST17"
        group.long 0x12004--0x12007 "BAM_P_RST17 (at 0xFE116004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT17"
        group.long 0x12008--0x1200B "BAM_P_HALT17 (at 0xFE116008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG17"
        group.long 0x12030--0x12033 "BAM_P_TRUST_REG17 (at 0xFE116030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS17"
        group.long 0x12010--0x12013 "BAM_P_IRQ_STTS17 (at 0xFE116010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR17"
        group.long 0x12014--0x12017 "BAM_P_IRQ_CLR17 (at 0xFE116014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN17"
        group.long 0x12018--0x1201B "BAM_P_IRQ_EN17 (at 0xFE116018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER17"
        group.long 0x1201C--0x1201F "BAM_P_TIMER17 (at 0xFE11601C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL17"
        group.long 0x12020--0x12023 "BAM_P_TIMER_CTRL17 (at 0xFE116020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND17"
        group.long 0x12024--0x12027 "BAM_P_PRDCR_SDBND17 (at 0xFE116024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND17"
        group.long 0x12028--0x1202B "BAM_P_CNSMR_SDBND17 (at 0xFE116028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR17"
        group.long 0x1282C--0x1282F "BAM_P_EVNT_DEST_ADDR17 (at 0xFE11682C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG17"
        group.long 0x12818--0x1281B "BAM_P_EVNT_REG17 (at 0xFE116818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS17"
        group.long 0x12800--0x12803 "BAM_P_SW_OFSTS17 (at 0xFE116800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR17"
        group.long 0x12824--0x12827 "BAM_P_DATA_FIFO_ADDR17 (at 0xFE116824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR17"
        group.long 0x1281C--0x1281F "BAM_P_DESC_FIFO_ADDR17 (at 0xFE11681C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD17"
        group.long 0x12828--0x1282B "BAM_P_EVNT_GEN_TRSHLD17 (at 0xFE116828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES17"
        group.long 0x12820--0x12823 "BAM_P_FIFO_SIZES17 (at 0xFE116820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_17"
        group.long 0x12834--0x12837 "BAM_P_RETR_CNTXT_17 (at 0xFE116834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_17"
        group.long 0x12838--0x1283B "BAM_P_SI_CNTXT_17 (at 0xFE116838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_17"
        group.long 0x12830--0x12833 "BAM_P_DF_CNTXT_17 (at 0xFE116830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_17"
        group.long 0x12804--0x12807 "BAM_P_AU_PSM_CNTXT_1_17 (at 0xFE116804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_17"
        group.long 0x12808--0x1280B "BAM_P_PSM_CNTXT_2_17 (at 0xFE116808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_17"
        group.long 0x1280C--0x1280F "BAM_P_PSM_CNTXT_3_17 (at 0xFE11680C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_17"
        group.long 0x12810--0x12813 "BAM_P_PSM_CNTXT_4_17 (at 0xFE116810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_17"
        group.long 0x12814--0x12817 "BAM_P_PSM_CNTXT_5_17 (at 0xFE116814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 17
tree.end
tree "Pipe 18"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL18"
        group.long 0x13000--0x13003 "BAM_P_CTRL18 (at 0xFE117000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST18"
        group.long 0x13004--0x13007 "BAM_P_RST18 (at 0xFE117004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT18"
        group.long 0x13008--0x1300B "BAM_P_HALT18 (at 0xFE117008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG18"
        group.long 0x13030--0x13033 "BAM_P_TRUST_REG18 (at 0xFE117030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS18"
        group.long 0x13010--0x13013 "BAM_P_IRQ_STTS18 (at 0xFE117010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR18"
        group.long 0x13014--0x13017 "BAM_P_IRQ_CLR18 (at 0xFE117014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN18"
        group.long 0x13018--0x1301B "BAM_P_IRQ_EN18 (at 0xFE117018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER18"
        group.long 0x1301C--0x1301F "BAM_P_TIMER18 (at 0xFE11701C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL18"
        group.long 0x13020--0x13023 "BAM_P_TIMER_CTRL18 (at 0xFE117020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND18"
        group.long 0x13024--0x13027 "BAM_P_PRDCR_SDBND18 (at 0xFE117024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND18"
        group.long 0x13028--0x1302B "BAM_P_CNSMR_SDBND18 (at 0xFE117028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR18"
        group.long 0x1382C--0x1382F "BAM_P_EVNT_DEST_ADDR18 (at 0xFE11782C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG18"
        group.long 0x13818--0x1381B "BAM_P_EVNT_REG18 (at 0xFE117818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS18"
        group.long 0x13800--0x13803 "BAM_P_SW_OFSTS18 (at 0xFE117800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR18"
        group.long 0x13824--0x13827 "BAM_P_DATA_FIFO_ADDR18 (at 0xFE117824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR18"
        group.long 0x1381C--0x1381F "BAM_P_DESC_FIFO_ADDR18 (at 0xFE11781C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD18"
        group.long 0x13828--0x1382B "BAM_P_EVNT_GEN_TRSHLD18 (at 0xFE117828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES18"
        group.long 0x13820--0x13823 "BAM_P_FIFO_SIZES18 (at 0xFE117820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_18"
        group.long 0x13834--0x13837 "BAM_P_RETR_CNTXT_18 (at 0xFE117834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_18"
        group.long 0x13838--0x1383B "BAM_P_SI_CNTXT_18 (at 0xFE117838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_18"
        group.long 0x13830--0x13833 "BAM_P_DF_CNTXT_18 (at 0xFE117830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_18"
        group.long 0x13804--0x13807 "BAM_P_AU_PSM_CNTXT_1_18 (at 0xFE117804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_18"
        group.long 0x13808--0x1380B "BAM_P_PSM_CNTXT_2_18 (at 0xFE117808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_18"
        group.long 0x1380C--0x1380F "BAM_P_PSM_CNTXT_3_18 (at 0xFE11780C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_18"
        group.long 0x13810--0x13813 "BAM_P_PSM_CNTXT_4_18 (at 0xFE117810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_18"
        group.long 0x13814--0x13817 "BAM_P_PSM_CNTXT_5_18 (at 0xFE117814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 18
tree.end
tree "Pipe 19"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL19"
        group.long 0x14000--0x14003 "BAM_P_CTRL19 (at 0xFE118000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST19"
        group.long 0x14004--0x14007 "BAM_P_RST19 (at 0xFE118004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT19"
        group.long 0x14008--0x1400B "BAM_P_HALT19 (at 0xFE118008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG19"
        group.long 0x14030--0x14033 "BAM_P_TRUST_REG19 (at 0xFE118030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS19"
        group.long 0x14010--0x14013 "BAM_P_IRQ_STTS19 (at 0xFE118010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR19"
        group.long 0x14014--0x14017 "BAM_P_IRQ_CLR19 (at 0xFE118014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN19"
        group.long 0x14018--0x1401B "BAM_P_IRQ_EN19 (at 0xFE118018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER19"
        group.long 0x1401C--0x1401F "BAM_P_TIMER19 (at 0xFE11801C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL19"
        group.long 0x14020--0x14023 "BAM_P_TIMER_CTRL19 (at 0xFE118020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND19"
        group.long 0x14024--0x14027 "BAM_P_PRDCR_SDBND19 (at 0xFE118024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND19"
        group.long 0x14028--0x1402B "BAM_P_CNSMR_SDBND19 (at 0xFE118028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR19"
        group.long 0x1482C--0x1482F "BAM_P_EVNT_DEST_ADDR19 (at 0xFE11882C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG19"
        group.long 0x14818--0x1481B "BAM_P_EVNT_REG19 (at 0xFE118818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS19"
        group.long 0x14800--0x14803 "BAM_P_SW_OFSTS19 (at 0xFE118800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR19"
        group.long 0x14824--0x14827 "BAM_P_DATA_FIFO_ADDR19 (at 0xFE118824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR19"
        group.long 0x1481C--0x1481F "BAM_P_DESC_FIFO_ADDR19 (at 0xFE11881C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD19"
        group.long 0x14828--0x1482B "BAM_P_EVNT_GEN_TRSHLD19 (at 0xFE118828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES19"
        group.long 0x14820--0x14823 "BAM_P_FIFO_SIZES19 (at 0xFE118820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_19"
        group.long 0x14834--0x14837 "BAM_P_RETR_CNTXT_19 (at 0xFE118834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_19"
        group.long 0x14838--0x1483B "BAM_P_SI_CNTXT_19 (at 0xFE118838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_19"
        group.long 0x14830--0x14833 "BAM_P_DF_CNTXT_19 (at 0xFE118830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_19"
        group.long 0x14804--0x14807 "BAM_P_AU_PSM_CNTXT_1_19 (at 0xFE118804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_19"
        group.long 0x14808--0x1480B "BAM_P_PSM_CNTXT_2_19 (at 0xFE118808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_19"
        group.long 0x1480C--0x1480F "BAM_P_PSM_CNTXT_3_19 (at 0xFE11880C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_19"
        group.long 0x14810--0x14813 "BAM_P_PSM_CNTXT_4_19 (at 0xFE118810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_19"
        group.long 0x14814--0x14817 "BAM_P_PSM_CNTXT_5_19 (at 0xFE118814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 19
tree.end
tree "Pipe 20"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL20"
        group.long 0x15000--0x15003 "BAM_P_CTRL20 (at 0xFE119000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST20"
        group.long 0x15004--0x15007 "BAM_P_RST20 (at 0xFE119004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT20"
        group.long 0x15008--0x1500B "BAM_P_HALT20 (at 0xFE119008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG20"
        group.long 0x15030--0x15033 "BAM_P_TRUST_REG20 (at 0xFE119030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS20"
        group.long 0x15010--0x15013 "BAM_P_IRQ_STTS20 (at 0xFE119010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR20"
        group.long 0x15014--0x15017 "BAM_P_IRQ_CLR20 (at 0xFE119014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN20"
        group.long 0x15018--0x1501B "BAM_P_IRQ_EN20 (at 0xFE119018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER20"
        group.long 0x1501C--0x1501F "BAM_P_TIMER20 (at 0xFE11901C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL20"
        group.long 0x15020--0x15023 "BAM_P_TIMER_CTRL20 (at 0xFE119020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND20"
        group.long 0x15024--0x15027 "BAM_P_PRDCR_SDBND20 (at 0xFE119024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND20"
        group.long 0x15028--0x1502B "BAM_P_CNSMR_SDBND20 (at 0xFE119028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR20"
        group.long 0x1582C--0x1582F "BAM_P_EVNT_DEST_ADDR20 (at 0xFE11982C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG20"
        group.long 0x15818--0x1581B "BAM_P_EVNT_REG20 (at 0xFE119818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS20"
        group.long 0x15800--0x15803 "BAM_P_SW_OFSTS20 (at 0xFE119800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR20"
        group.long 0x15824--0x15827 "BAM_P_DATA_FIFO_ADDR20 (at 0xFE119824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR20"
        group.long 0x1581C--0x1581F "BAM_P_DESC_FIFO_ADDR20 (at 0xFE11981C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD20"
        group.long 0x15828--0x1582B "BAM_P_EVNT_GEN_TRSHLD20 (at 0xFE119828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES20"
        group.long 0x15820--0x15823 "BAM_P_FIFO_SIZES20 (at 0xFE119820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_20"
        group.long 0x15834--0x15837 "BAM_P_RETR_CNTXT_20 (at 0xFE119834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_20"
        group.long 0x15838--0x1583B "BAM_P_SI_CNTXT_20 (at 0xFE119838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_20"
        group.long 0x15830--0x15833 "BAM_P_DF_CNTXT_20 (at 0xFE119830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_20"
        group.long 0x15804--0x15807 "BAM_P_AU_PSM_CNTXT_1_20 (at 0xFE119804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_20"
        group.long 0x15808--0x1580B "BAM_P_PSM_CNTXT_2_20 (at 0xFE119808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_20"
        group.long 0x1580C--0x1580F "BAM_P_PSM_CNTXT_3_20 (at 0xFE11980C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_20"
        group.long 0x15810--0x15813 "BAM_P_PSM_CNTXT_4_20 (at 0xFE119810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_20"
        group.long 0x15814--0x15817 "BAM_P_PSM_CNTXT_5_20 (at 0xFE119814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 20
tree.end
tree "Pipe 21"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL21"
        group.long 0x16000--0x16003 "BAM_P_CTRL21 (at 0xFE11A000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST21"
        group.long 0x16004--0x16007 "BAM_P_RST21 (at 0xFE11A004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT21"
        group.long 0x16008--0x1600B "BAM_P_HALT21 (at 0xFE11A008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG21"
        group.long 0x16030--0x16033 "BAM_P_TRUST_REG21 (at 0xFE11A030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS21"
        group.long 0x16010--0x16013 "BAM_P_IRQ_STTS21 (at 0xFE11A010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR21"
        group.long 0x16014--0x16017 "BAM_P_IRQ_CLR21 (at 0xFE11A014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN21"
        group.long 0x16018--0x1601B "BAM_P_IRQ_EN21 (at 0xFE11A018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER21"
        group.long 0x1601C--0x1601F "BAM_P_TIMER21 (at 0xFE11A01C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL21"
        group.long 0x16020--0x16023 "BAM_P_TIMER_CTRL21 (at 0xFE11A020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND21"
        group.long 0x16024--0x16027 "BAM_P_PRDCR_SDBND21 (at 0xFE11A024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND21"
        group.long 0x16028--0x1602B "BAM_P_CNSMR_SDBND21 (at 0xFE11A028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR21"
        group.long 0x1682C--0x1682F "BAM_P_EVNT_DEST_ADDR21 (at 0xFE11A82C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG21"
        group.long 0x16818--0x1681B "BAM_P_EVNT_REG21 (at 0xFE11A818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS21"
        group.long 0x16800--0x16803 "BAM_P_SW_OFSTS21 (at 0xFE11A800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR21"
        group.long 0x16824--0x16827 "BAM_P_DATA_FIFO_ADDR21 (at 0xFE11A824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR21"
        group.long 0x1681C--0x1681F "BAM_P_DESC_FIFO_ADDR21 (at 0xFE11A81C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD21"
        group.long 0x16828--0x1682B "BAM_P_EVNT_GEN_TRSHLD21 (at 0xFE11A828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES21"
        group.long 0x16820--0x16823 "BAM_P_FIFO_SIZES21 (at 0xFE11A820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_21"
        group.long 0x16834--0x16837 "BAM_P_RETR_CNTXT_21 (at 0xFE11A834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_21"
        group.long 0x16838--0x1683B "BAM_P_SI_CNTXT_21 (at 0xFE11A838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_21"
        group.long 0x16830--0x16833 "BAM_P_DF_CNTXT_21 (at 0xFE11A830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_21"
        group.long 0x16804--0x16807 "BAM_P_AU_PSM_CNTXT_1_21 (at 0xFE11A804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_21"
        group.long 0x16808--0x1680B "BAM_P_PSM_CNTXT_2_21 (at 0xFE11A808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_21"
        group.long 0x1680C--0x1680F "BAM_P_PSM_CNTXT_3_21 (at 0xFE11A80C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_21"
        group.long 0x16810--0x16813 "BAM_P_PSM_CNTXT_4_21 (at 0xFE11A810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_21"
        group.long 0x16814--0x16817 "BAM_P_PSM_CNTXT_5_21 (at 0xFE11A814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 21
tree.end
tree "Pipe 22"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL22"
        group.long 0x17000--0x17003 "BAM_P_CTRL22 (at 0xFE11B000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST22"
        group.long 0x17004--0x17007 "BAM_P_RST22 (at 0xFE11B004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT22"
        group.long 0x17008--0x1700B "BAM_P_HALT22 (at 0xFE11B008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG22"
        group.long 0x17030--0x17033 "BAM_P_TRUST_REG22 (at 0xFE11B030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS22"
        group.long 0x17010--0x17013 "BAM_P_IRQ_STTS22 (at 0xFE11B010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR22"
        group.long 0x17014--0x17017 "BAM_P_IRQ_CLR22 (at 0xFE11B014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN22"
        group.long 0x17018--0x1701B "BAM_P_IRQ_EN22 (at 0xFE11B018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER22"
        group.long 0x1701C--0x1701F "BAM_P_TIMER22 (at 0xFE11B01C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL22"
        group.long 0x17020--0x17023 "BAM_P_TIMER_CTRL22 (at 0xFE11B020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND22"
        group.long 0x17024--0x17027 "BAM_P_PRDCR_SDBND22 (at 0xFE11B024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND22"
        group.long 0x17028--0x1702B "BAM_P_CNSMR_SDBND22 (at 0xFE11B028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR22"
        group.long 0x1782C--0x1782F "BAM_P_EVNT_DEST_ADDR22 (at 0xFE11B82C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG22"
        group.long 0x17818--0x1781B "BAM_P_EVNT_REG22 (at 0xFE11B818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS22"
        group.long 0x17800--0x17803 "BAM_P_SW_OFSTS22 (at 0xFE11B800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR22"
        group.long 0x17824--0x17827 "BAM_P_DATA_FIFO_ADDR22 (at 0xFE11B824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR22"
        group.long 0x1781C--0x1781F "BAM_P_DESC_FIFO_ADDR22 (at 0xFE11B81C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD22"
        group.long 0x17828--0x1782B "BAM_P_EVNT_GEN_TRSHLD22 (at 0xFE11B828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES22"
        group.long 0x17820--0x17823 "BAM_P_FIFO_SIZES22 (at 0xFE11B820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_22"
        group.long 0x17834--0x17837 "BAM_P_RETR_CNTXT_22 (at 0xFE11B834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_22"
        group.long 0x17838--0x1783B "BAM_P_SI_CNTXT_22 (at 0xFE11B838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_22"
        group.long 0x17830--0x17833 "BAM_P_DF_CNTXT_22 (at 0xFE11B830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_22"
        group.long 0x17804--0x17807 "BAM_P_AU_PSM_CNTXT_1_22 (at 0xFE11B804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_22"
        group.long 0x17808--0x1780B "BAM_P_PSM_CNTXT_2_22 (at 0xFE11B808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_22"
        group.long 0x1780C--0x1780F "BAM_P_PSM_CNTXT_3_22 (at 0xFE11B80C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_22"
        group.long 0x17810--0x17813 "BAM_P_PSM_CNTXT_4_22 (at 0xFE11B810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_22"
        group.long 0x17814--0x17817 "BAM_P_PSM_CNTXT_5_22 (at 0xFE11B814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 22
tree.end
tree "Pipe 23"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL23"
        group.long 0x18000--0x18003 "BAM_P_CTRL23 (at 0xFE11C000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST23"
        group.long 0x18004--0x18007 "BAM_P_RST23 (at 0xFE11C004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT23"
        group.long 0x18008--0x1800B "BAM_P_HALT23 (at 0xFE11C008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG23"
        group.long 0x18030--0x18033 "BAM_P_TRUST_REG23 (at 0xFE11C030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS23"
        group.long 0x18010--0x18013 "BAM_P_IRQ_STTS23 (at 0xFE11C010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR23"
        group.long 0x18014--0x18017 "BAM_P_IRQ_CLR23 (at 0xFE11C014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN23"
        group.long 0x18018--0x1801B "BAM_P_IRQ_EN23 (at 0xFE11C018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER23"
        group.long 0x1801C--0x1801F "BAM_P_TIMER23 (at 0xFE11C01C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL23"
        group.long 0x18020--0x18023 "BAM_P_TIMER_CTRL23 (at 0xFE11C020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND23"
        group.long 0x18024--0x18027 "BAM_P_PRDCR_SDBND23 (at 0xFE11C024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND23"
        group.long 0x18028--0x1802B "BAM_P_CNSMR_SDBND23 (at 0xFE11C028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR23"
        group.long 0x1882C--0x1882F "BAM_P_EVNT_DEST_ADDR23 (at 0xFE11C82C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG23"
        group.long 0x18818--0x1881B "BAM_P_EVNT_REG23 (at 0xFE11C818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS23"
        group.long 0x18800--0x18803 "BAM_P_SW_OFSTS23 (at 0xFE11C800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR23"
        group.long 0x18824--0x18827 "BAM_P_DATA_FIFO_ADDR23 (at 0xFE11C824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR23"
        group.long 0x1881C--0x1881F "BAM_P_DESC_FIFO_ADDR23 (at 0xFE11C81C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD23"
        group.long 0x18828--0x1882B "BAM_P_EVNT_GEN_TRSHLD23 (at 0xFE11C828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES23"
        group.long 0x18820--0x18823 "BAM_P_FIFO_SIZES23 (at 0xFE11C820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_23"
        group.long 0x18834--0x18837 "BAM_P_RETR_CNTXT_23 (at 0xFE11C834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_23"
        group.long 0x18838--0x1883B "BAM_P_SI_CNTXT_23 (at 0xFE11C838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_23"
        group.long 0x18830--0x18833 "BAM_P_DF_CNTXT_23 (at 0xFE11C830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_23"
        group.long 0x18804--0x18807 "BAM_P_AU_PSM_CNTXT_1_23 (at 0xFE11C804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_23"
        group.long 0x18808--0x1880B "BAM_P_PSM_CNTXT_2_23 (at 0xFE11C808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_23"
        group.long 0x1880C--0x1880F "BAM_P_PSM_CNTXT_3_23 (at 0xFE11C80C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_23"
        group.long 0x18810--0x18813 "BAM_P_PSM_CNTXT_4_23 (at 0xFE11C810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_23"
        group.long 0x18814--0x18817 "BAM_P_PSM_CNTXT_5_23 (at 0xFE11C814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 23
tree.end
tree "Pipe 24"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL24"
        group.long 0x19000--0x19003 "BAM_P_CTRL24 (at 0xFE11D000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST24"
        group.long 0x19004--0x19007 "BAM_P_RST24 (at 0xFE11D004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT24"
        group.long 0x19008--0x1900B "BAM_P_HALT24 (at 0xFE11D008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG24"
        group.long 0x19030--0x19033 "BAM_P_TRUST_REG24 (at 0xFE11D030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS24"
        group.long 0x19010--0x19013 "BAM_P_IRQ_STTS24 (at 0xFE11D010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR24"
        group.long 0x19014--0x19017 "BAM_P_IRQ_CLR24 (at 0xFE11D014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN24"
        group.long 0x19018--0x1901B "BAM_P_IRQ_EN24 (at 0xFE11D018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER24"
        group.long 0x1901C--0x1901F "BAM_P_TIMER24 (at 0xFE11D01C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL24"
        group.long 0x19020--0x19023 "BAM_P_TIMER_CTRL24 (at 0xFE11D020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND24"
        group.long 0x19024--0x19027 "BAM_P_PRDCR_SDBND24 (at 0xFE11D024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND24"
        group.long 0x19028--0x1902B "BAM_P_CNSMR_SDBND24 (at 0xFE11D028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR24"
        group.long 0x1982C--0x1982F "BAM_P_EVNT_DEST_ADDR24 (at 0xFE11D82C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG24"
        group.long 0x19818--0x1981B "BAM_P_EVNT_REG24 (at 0xFE11D818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS24"
        group.long 0x19800--0x19803 "BAM_P_SW_OFSTS24 (at 0xFE11D800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR24"
        group.long 0x19824--0x19827 "BAM_P_DATA_FIFO_ADDR24 (at 0xFE11D824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR24"
        group.long 0x1981C--0x1981F "BAM_P_DESC_FIFO_ADDR24 (at 0xFE11D81C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD24"
        group.long 0x19828--0x1982B "BAM_P_EVNT_GEN_TRSHLD24 (at 0xFE11D828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES24"
        group.long 0x19820--0x19823 "BAM_P_FIFO_SIZES24 (at 0xFE11D820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_24"
        group.long 0x19834--0x19837 "BAM_P_RETR_CNTXT_24 (at 0xFE11D834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_24"
        group.long 0x19838--0x1983B "BAM_P_SI_CNTXT_24 (at 0xFE11D838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_24"
        group.long 0x19830--0x19833 "BAM_P_DF_CNTXT_24 (at 0xFE11D830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_24"
        group.long 0x19804--0x19807 "BAM_P_AU_PSM_CNTXT_1_24 (at 0xFE11D804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_24"
        group.long 0x19808--0x1980B "BAM_P_PSM_CNTXT_2_24 (at 0xFE11D808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_24"
        group.long 0x1980C--0x1980F "BAM_P_PSM_CNTXT_3_24 (at 0xFE11D80C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_24"
        group.long 0x19810--0x19813 "BAM_P_PSM_CNTXT_4_24 (at 0xFE11D810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_24"
        group.long 0x19814--0x19817 "BAM_P_PSM_CNTXT_5_24 (at 0xFE11D814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 24
tree.end
tree "Pipe 25"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL25"
        group.long 0x1A000--0x1A003 "BAM_P_CTRL25 (at 0xFE11E000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST25"
        group.long 0x1A004--0x1A007 "BAM_P_RST25 (at 0xFE11E004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT25"
        group.long 0x1A008--0x1A00B "BAM_P_HALT25 (at 0xFE11E008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG25"
        group.long 0x1A030--0x1A033 "BAM_P_TRUST_REG25 (at 0xFE11E030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS25"
        group.long 0x1A010--0x1A013 "BAM_P_IRQ_STTS25 (at 0xFE11E010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR25"
        group.long 0x1A014--0x1A017 "BAM_P_IRQ_CLR25 (at 0xFE11E014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN25"
        group.long 0x1A018--0x1A01B "BAM_P_IRQ_EN25 (at 0xFE11E018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER25"
        group.long 0x1A01C--0x1A01F "BAM_P_TIMER25 (at 0xFE11E01C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL25"
        group.long 0x1A020--0x1A023 "BAM_P_TIMER_CTRL25 (at 0xFE11E020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND25"
        group.long 0x1A024--0x1A027 "BAM_P_PRDCR_SDBND25 (at 0xFE11E024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND25"
        group.long 0x1A028--0x1A02B "BAM_P_CNSMR_SDBND25 (at 0xFE11E028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR25"
        group.long 0x1A82C--0x1A82F "BAM_P_EVNT_DEST_ADDR25 (at 0xFE11E82C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG25"
        group.long 0x1A818--0x1A81B "BAM_P_EVNT_REG25 (at 0xFE11E818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS25"
        group.long 0x1A800--0x1A803 "BAM_P_SW_OFSTS25 (at 0xFE11E800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR25"
        group.long 0x1A824--0x1A827 "BAM_P_DATA_FIFO_ADDR25 (at 0xFE11E824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR25"
        group.long 0x1A81C--0x1A81F "BAM_P_DESC_FIFO_ADDR25 (at 0xFE11E81C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD25"
        group.long 0x1A828--0x1A82B "BAM_P_EVNT_GEN_TRSHLD25 (at 0xFE11E828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES25"
        group.long 0x1A820--0x1A823 "BAM_P_FIFO_SIZES25 (at 0xFE11E820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_25"
        group.long 0x1A834--0x1A837 "BAM_P_RETR_CNTXT_25 (at 0xFE11E834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_25"
        group.long 0x1A838--0x1A83B "BAM_P_SI_CNTXT_25 (at 0xFE11E838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_25"
        group.long 0x1A830--0x1A833 "BAM_P_DF_CNTXT_25 (at 0xFE11E830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_25"
        group.long 0x1A804--0x1A807 "BAM_P_AU_PSM_CNTXT_1_25 (at 0xFE11E804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_25"
        group.long 0x1A808--0x1A80B "BAM_P_PSM_CNTXT_2_25 (at 0xFE11E808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_25"
        group.long 0x1A80C--0x1A80F "BAM_P_PSM_CNTXT_3_25 (at 0xFE11E80C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_25"
        group.long 0x1A810--0x1A813 "BAM_P_PSM_CNTXT_4_25 (at 0xFE11E810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_25"
        group.long 0x1A814--0x1A817 "BAM_P_PSM_CNTXT_5_25 (at 0xFE11E814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 25
tree.end
tree "Pipe 26"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL26"
        group.long 0x1B000--0x1B003 "BAM_P_CTRL26 (at 0xFE11F000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST26"
        group.long 0x1B004--0x1B007 "BAM_P_RST26 (at 0xFE11F004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT26"
        group.long 0x1B008--0x1B00B "BAM_P_HALT26 (at 0xFE11F008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG26"
        group.long 0x1B030--0x1B033 "BAM_P_TRUST_REG26 (at 0xFE11F030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS26"
        group.long 0x1B010--0x1B013 "BAM_P_IRQ_STTS26 (at 0xFE11F010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR26"
        group.long 0x1B014--0x1B017 "BAM_P_IRQ_CLR26 (at 0xFE11F014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN26"
        group.long 0x1B018--0x1B01B "BAM_P_IRQ_EN26 (at 0xFE11F018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER26"
        group.long 0x1B01C--0x1B01F "BAM_P_TIMER26 (at 0xFE11F01C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL26"
        group.long 0x1B020--0x1B023 "BAM_P_TIMER_CTRL26 (at 0xFE11F020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND26"
        group.long 0x1B024--0x1B027 "BAM_P_PRDCR_SDBND26 (at 0xFE11F024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND26"
        group.long 0x1B028--0x1B02B "BAM_P_CNSMR_SDBND26 (at 0xFE11F028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR26"
        group.long 0x1B82C--0x1B82F "BAM_P_EVNT_DEST_ADDR26 (at 0xFE11F82C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG26"
        group.long 0x1B818--0x1B81B "BAM_P_EVNT_REG26 (at 0xFE11F818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS26"
        group.long 0x1B800--0x1B803 "BAM_P_SW_OFSTS26 (at 0xFE11F800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR26"
        group.long 0x1B824--0x1B827 "BAM_P_DATA_FIFO_ADDR26 (at 0xFE11F824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR26"
        group.long 0x1B81C--0x1B81F "BAM_P_DESC_FIFO_ADDR26 (at 0xFE11F81C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD26"
        group.long 0x1B828--0x1B82B "BAM_P_EVNT_GEN_TRSHLD26 (at 0xFE11F828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES26"
        group.long 0x1B820--0x1B823 "BAM_P_FIFO_SIZES26 (at 0xFE11F820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_26"
        group.long 0x1B834--0x1B837 "BAM_P_RETR_CNTXT_26 (at 0xFE11F834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_26"
        group.long 0x1B838--0x1B83B "BAM_P_SI_CNTXT_26 (at 0xFE11F838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_26"
        group.long 0x1B830--0x1B833 "BAM_P_DF_CNTXT_26 (at 0xFE11F830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_26"
        group.long 0x1B804--0x1B807 "BAM_P_AU_PSM_CNTXT_1_26 (at 0xFE11F804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_26"
        group.long 0x1B808--0x1B80B "BAM_P_PSM_CNTXT_2_26 (at 0xFE11F808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_26"
        group.long 0x1B80C--0x1B80F "BAM_P_PSM_CNTXT_3_26 (at 0xFE11F80C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_26"
        group.long 0x1B810--0x1B813 "BAM_P_PSM_CNTXT_4_26 (at 0xFE11F810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_26"
        group.long 0x1B814--0x1B817 "BAM_P_PSM_CNTXT_5_26 (at 0xFE11F814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 26
tree.end
tree "Pipe 27"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL27"
        group.long 0x1C000--0x1C003 "BAM_P_CTRL27 (at 0xFE120000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST27"
        group.long 0x1C004--0x1C007 "BAM_P_RST27 (at 0xFE120004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT27"
        group.long 0x1C008--0x1C00B "BAM_P_HALT27 (at 0xFE120008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG27"
        group.long 0x1C030--0x1C033 "BAM_P_TRUST_REG27 (at 0xFE120030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS27"
        group.long 0x1C010--0x1C013 "BAM_P_IRQ_STTS27 (at 0xFE120010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR27"
        group.long 0x1C014--0x1C017 "BAM_P_IRQ_CLR27 (at 0xFE120014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN27"
        group.long 0x1C018--0x1C01B "BAM_P_IRQ_EN27 (at 0xFE120018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER27"
        group.long 0x1C01C--0x1C01F "BAM_P_TIMER27 (at 0xFE12001C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL27"
        group.long 0x1C020--0x1C023 "BAM_P_TIMER_CTRL27 (at 0xFE120020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND27"
        group.long 0x1C024--0x1C027 "BAM_P_PRDCR_SDBND27 (at 0xFE120024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND27"
        group.long 0x1C028--0x1C02B "BAM_P_CNSMR_SDBND27 (at 0xFE120028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR27"
        group.long 0x1C82C--0x1C82F "BAM_P_EVNT_DEST_ADDR27 (at 0xFE12082C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG27"
        group.long 0x1C818--0x1C81B "BAM_P_EVNT_REG27 (at 0xFE120818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS27"
        group.long 0x1C800--0x1C803 "BAM_P_SW_OFSTS27 (at 0xFE120800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR27"
        group.long 0x1C824--0x1C827 "BAM_P_DATA_FIFO_ADDR27 (at 0xFE120824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR27"
        group.long 0x1C81C--0x1C81F "BAM_P_DESC_FIFO_ADDR27 (at 0xFE12081C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD27"
        group.long 0x1C828--0x1C82B "BAM_P_EVNT_GEN_TRSHLD27 (at 0xFE120828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES27"
        group.long 0x1C820--0x1C823 "BAM_P_FIFO_SIZES27 (at 0xFE120820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_27"
        group.long 0x1C834--0x1C837 "BAM_P_RETR_CNTXT_27 (at 0xFE120834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_27"
        group.long 0x1C838--0x1C83B "BAM_P_SI_CNTXT_27 (at 0xFE120838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_27"
        group.long 0x1C830--0x1C833 "BAM_P_DF_CNTXT_27 (at 0xFE120830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_27"
        group.long 0x1C804--0x1C807 "BAM_P_AU_PSM_CNTXT_1_27 (at 0xFE120804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_27"
        group.long 0x1C808--0x1C80B "BAM_P_PSM_CNTXT_2_27 (at 0xFE120808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_27"
        group.long 0x1C80C--0x1C80F "BAM_P_PSM_CNTXT_3_27 (at 0xFE12080C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_27"
        group.long 0x1C810--0x1C813 "BAM_P_PSM_CNTXT_4_27 (at 0xFE120810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_27"
        group.long 0x1C814--0x1C817 "BAM_P_PSM_CNTXT_5_27 (at 0xFE120814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 27
tree.end
tree "Pipe 28"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL28"
        group.long 0x1D000--0x1D003 "BAM_P_CTRL28 (at 0xFE121000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST28"
        group.long 0x1D004--0x1D007 "BAM_P_RST28 (at 0xFE121004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT28"
        group.long 0x1D008--0x1D00B "BAM_P_HALT28 (at 0xFE121008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG28"
        group.long 0x1D030--0x1D033 "BAM_P_TRUST_REG28 (at 0xFE121030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS28"
        group.long 0x1D010--0x1D013 "BAM_P_IRQ_STTS28 (at 0xFE121010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR28"
        group.long 0x1D014--0x1D017 "BAM_P_IRQ_CLR28 (at 0xFE121014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN28"
        group.long 0x1D018--0x1D01B "BAM_P_IRQ_EN28 (at 0xFE121018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER28"
        group.long 0x1D01C--0x1D01F "BAM_P_TIMER28 (at 0xFE12101C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL28"
        group.long 0x1D020--0x1D023 "BAM_P_TIMER_CTRL28 (at 0xFE121020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND28"
        group.long 0x1D024--0x1D027 "BAM_P_PRDCR_SDBND28 (at 0xFE121024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND28"
        group.long 0x1D028--0x1D02B "BAM_P_CNSMR_SDBND28 (at 0xFE121028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR28"
        group.long 0x1D82C--0x1D82F "BAM_P_EVNT_DEST_ADDR28 (at 0xFE12182C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG28"
        group.long 0x1D818--0x1D81B "BAM_P_EVNT_REG28 (at 0xFE121818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS28"
        group.long 0x1D800--0x1D803 "BAM_P_SW_OFSTS28 (at 0xFE121800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR28"
        group.long 0x1D824--0x1D827 "BAM_P_DATA_FIFO_ADDR28 (at 0xFE121824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR28"
        group.long 0x1D81C--0x1D81F "BAM_P_DESC_FIFO_ADDR28 (at 0xFE12181C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD28"
        group.long 0x1D828--0x1D82B "BAM_P_EVNT_GEN_TRSHLD28 (at 0xFE121828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES28"
        group.long 0x1D820--0x1D823 "BAM_P_FIFO_SIZES28 (at 0xFE121820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_28"
        group.long 0x1D834--0x1D837 "BAM_P_RETR_CNTXT_28 (at 0xFE121834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_28"
        group.long 0x1D838--0x1D83B "BAM_P_SI_CNTXT_28 (at 0xFE121838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_28"
        group.long 0x1D830--0x1D833 "BAM_P_DF_CNTXT_28 (at 0xFE121830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_28"
        group.long 0x1D804--0x1D807 "BAM_P_AU_PSM_CNTXT_1_28 (at 0xFE121804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_28"
        group.long 0x1D808--0x1D80B "BAM_P_PSM_CNTXT_2_28 (at 0xFE121808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_28"
        group.long 0x1D80C--0x1D80F "BAM_P_PSM_CNTXT_3_28 (at 0xFE12180C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_28"
        group.long 0x1D810--0x1D813 "BAM_P_PSM_CNTXT_4_28 (at 0xFE121810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_28"
        group.long 0x1D814--0x1D817 "BAM_P_PSM_CNTXT_5_28 (at 0xFE121814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 28
tree.end
tree "Pipe 29"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL29"
        group.long 0x1E000--0x1E003 "BAM_P_CTRL29 (at 0xFE122000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST29"
        group.long 0x1E004--0x1E007 "BAM_P_RST29 (at 0xFE122004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT29"
        group.long 0x1E008--0x1E00B "BAM_P_HALT29 (at 0xFE122008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG29"
        group.long 0x1E030--0x1E033 "BAM_P_TRUST_REG29 (at 0xFE122030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS29"
        group.long 0x1E010--0x1E013 "BAM_P_IRQ_STTS29 (at 0xFE122010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR29"
        group.long 0x1E014--0x1E017 "BAM_P_IRQ_CLR29 (at 0xFE122014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN29"
        group.long 0x1E018--0x1E01B "BAM_P_IRQ_EN29 (at 0xFE122018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER29"
        group.long 0x1E01C--0x1E01F "BAM_P_TIMER29 (at 0xFE12201C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL29"
        group.long 0x1E020--0x1E023 "BAM_P_TIMER_CTRL29 (at 0xFE122020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND29"
        group.long 0x1E024--0x1E027 "BAM_P_PRDCR_SDBND29 (at 0xFE122024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND29"
        group.long 0x1E028--0x1E02B "BAM_P_CNSMR_SDBND29 (at 0xFE122028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR29"
        group.long 0x1E82C--0x1E82F "BAM_P_EVNT_DEST_ADDR29 (at 0xFE12282C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG29"
        group.long 0x1E818--0x1E81B "BAM_P_EVNT_REG29 (at 0xFE122818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS29"
        group.long 0x1E800--0x1E803 "BAM_P_SW_OFSTS29 (at 0xFE122800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR29"
        group.long 0x1E824--0x1E827 "BAM_P_DATA_FIFO_ADDR29 (at 0xFE122824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR29"
        group.long 0x1E81C--0x1E81F "BAM_P_DESC_FIFO_ADDR29 (at 0xFE12281C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD29"
        group.long 0x1E828--0x1E82B "BAM_P_EVNT_GEN_TRSHLD29 (at 0xFE122828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES29"
        group.long 0x1E820--0x1E823 "BAM_P_FIFO_SIZES29 (at 0xFE122820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_29"
        group.long 0x1E834--0x1E837 "BAM_P_RETR_CNTXT_29 (at 0xFE122834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_29"
        group.long 0x1E838--0x1E83B "BAM_P_SI_CNTXT_29 (at 0xFE122838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_29"
        group.long 0x1E830--0x1E833 "BAM_P_DF_CNTXT_29 (at 0xFE122830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_29"
        group.long 0x1E804--0x1E807 "BAM_P_AU_PSM_CNTXT_1_29 (at 0xFE122804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_29"
        group.long 0x1E808--0x1E80B "BAM_P_PSM_CNTXT_2_29 (at 0xFE122808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_29"
        group.long 0x1E80C--0x1E80F "BAM_P_PSM_CNTXT_3_29 (at 0xFE12280C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_29"
        group.long 0x1E810--0x1E813 "BAM_P_PSM_CNTXT_4_29 (at 0xFE122810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_29"
        group.long 0x1E814--0x1E817 "BAM_P_PSM_CNTXT_5_29 (at 0xFE122814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 29
tree.end
tree "Pipe 30"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL30"
        group.long 0x1F000--0x1F003 "BAM_P_CTRL30 (at 0xFE123000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST30"
        group.long 0x1F004--0x1F007 "BAM_P_RST30 (at 0xFE123004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT30"
        group.long 0x1F008--0x1F00B "BAM_P_HALT30 (at 0xFE123008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG30"
        group.long 0x1F030--0x1F033 "BAM_P_TRUST_REG30 (at 0xFE123030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS30"
        group.long 0x1F010--0x1F013 "BAM_P_IRQ_STTS30 (at 0xFE123010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR30"
        group.long 0x1F014--0x1F017 "BAM_P_IRQ_CLR30 (at 0xFE123014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN30"
        group.long 0x1F018--0x1F01B "BAM_P_IRQ_EN30 (at 0xFE123018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER30"
        group.long 0x1F01C--0x1F01F "BAM_P_TIMER30 (at 0xFE12301C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL30"
        group.long 0x1F020--0x1F023 "BAM_P_TIMER_CTRL30 (at 0xFE123020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND30"
        group.long 0x1F024--0x1F027 "BAM_P_PRDCR_SDBND30 (at 0xFE123024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND30"
        group.long 0x1F028--0x1F02B "BAM_P_CNSMR_SDBND30 (at 0xFE123028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR30"
        group.long 0x1F82C--0x1F82F "BAM_P_EVNT_DEST_ADDR30 (at 0xFE12382C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG30"
        group.long 0x1F818--0x1F81B "BAM_P_EVNT_REG30 (at 0xFE123818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS30"
        group.long 0x1F800--0x1F803 "BAM_P_SW_OFSTS30 (at 0xFE123800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR30"
        group.long 0x1F824--0x1F827 "BAM_P_DATA_FIFO_ADDR30 (at 0xFE123824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR30"
        group.long 0x1F81C--0x1F81F "BAM_P_DESC_FIFO_ADDR30 (at 0xFE12381C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD30"
        group.long 0x1F828--0x1F82B "BAM_P_EVNT_GEN_TRSHLD30 (at 0xFE123828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES30"
        group.long 0x1F820--0x1F823 "BAM_P_FIFO_SIZES30 (at 0xFE123820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_30"
        group.long 0x1F834--0x1F837 "BAM_P_RETR_CNTXT_30 (at 0xFE123834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_30"
        group.long 0x1F838--0x1F83B "BAM_P_SI_CNTXT_30 (at 0xFE123838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_30"
        group.long 0x1F830--0x1F833 "BAM_P_DF_CNTXT_30 (at 0xFE123830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_30"
        group.long 0x1F804--0x1F807 "BAM_P_AU_PSM_CNTXT_1_30 (at 0xFE123804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_30"
        group.long 0x1F808--0x1F80B "BAM_P_PSM_CNTXT_2_30 (at 0xFE123808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_30"
        group.long 0x1F80C--0x1F80F "BAM_P_PSM_CNTXT_3_30 (at 0xFE12380C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_30"
        group.long 0x1F810--0x1F813 "BAM_P_PSM_CNTXT_4_30 (at 0xFE123810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_30"
        group.long 0x1F814--0x1F817 "BAM_P_PSM_CNTXT_5_30 (at 0xFE123814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 30
tree.end
tree.end
;Block Per Data Ends

base ad:0xFC834000
tree "A2"
tree "BAM Control Registers"
      tree "BAM_CTRL"
        group.long 0x0--0x3 "BAM_CTRL (at 0xFC834000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x13 " [   19]   CACHE_MISS_ERR_RESP_EN                   = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11--0x12 " [18:17]   LOCAL_CLK_GATING                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   IBC_DISABLE                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0xF " [   15]   BAM_CACHED_DESC_STORE                    = "  "0,1"
        textline ""
        bitfld.long 0x0 0xD--0xE " [14:13]   BAM_DESC_CACHE_SEL                       = "  "0,1,2,3"
        textline ""
        hexmask.long.word 0x0 0x5--0xB 1  " [11:05]   BAM_TESTBUS_SEL                          = " 
        textline ""
        bitfld.long 0x0 0x4 " [   04]   BAM_EN_ACCUM                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_EN                                   = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   BAM_SW_RST                               = "  "0,1"
        textline ""
      tree.end
      tree "BAM_REVISION"
        group.long 0x4--0x7 "BAM_REVISION (at 0xFC834004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x18--0x1F 1  " [31:24]   INACTIV_TMR_BASE                         = " 
        textline ""
        bitfld.long 0x0 0x17 " [   23]   CMD_DESC_EN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15--0x16 " [22:21]   DESC_CACHE_DEPTH                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   NUM_INACTIV_TMRS                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x13 " [   19]   INACTIV_TMRS_EXST                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x12 " [   18]   HIGH_FREQUENCY_BAM                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11 " [   17]   BAM_HAS_NO_BYPASS                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   SECURED                                  = "  "0,1"
        textline ""
        bitfld.long 0x0 0xF " [   15]   USE_VMIDMT                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0xE " [   14]   AXI_ACTIVE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0xD " [   13]   CE_BUFFER_SIZE                           = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x8--0xB 1  " [11:08]   NUM_EES                                  = " 
        textline ""
        hexmask.long.word 0x0 0x0--0x7 1  " [07:00]   REVISION                                 = " 
        textline ""
      tree.end
      tree "BAM_SW_VERSION"
        group.long 0x80--0x83 "BAM_SW_VERSION (at 0xFC834080) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x1C--0x1F 1  " [31:28]   MAJOR                                    = " 
        textline ""
        hexmask.long.word 0x0 0x10--0x1B 1  " [27:16]   MINOR                                    = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   STEP                                     = " 
        textline ""
      tree.end
      tree "BAM_NUM_PIPES"
        group.long 0x3C--0x3F "BAM_NUM_PIPES (at 0xFC83403C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x18--0x1F 1  " [31:24]   BAM_NON_PIPE_GRP                         = " 
        textline ""
        hexmask.long.word 0x0 0x10--0x17 1  " [23:16]   PERIPH_NON_PIPE_GRP                      = " 
        textline ""
        hexmask.long.word 0x0 0x0--0x7 1  " [07:00]   BAM_NUM_PIPES                            = " 
        textline ""
      tree.end
      tree "BAM_TIMER"
        group.long 0x40--0x43 "BAM_TIMER (at 0xFC834040) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   TIMER                                    = " 
        textline ""
      tree.end
      tree "BAM_TIMER_CTRL"
        group.long 0x44--0x47 "BAM_TIMER_CTRL (at 0xFC834044) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   TIMER_RST                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   TIMER_RUN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   TIMER_MODE                               = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   TIMER_TRSHLD                             = " 
        textline ""
      tree.end
      tree "BAM_DESC_CNT_TRSHLD"
        group.long 0x8--0xB "BAM_DESC_CNT_TRSHLD (at 0xFC834008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   CNT_TRSHLD                               = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS"
        group.long 0xC--0xF "BAM_IRQ_SRCS (at 0xFC83400C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK"
        group.long 0x10--0x13 "BAM_IRQ_SRCS_MSK (at 0xFC834010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED"
        group.long 0x30--0x33 "BAM_IRQ_SRCS_UNMASKED (at 0xFC834030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_STTS"
        group.long 0x14--0x17 "BAM_IRQ_STTS (at 0xFC834014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x4 " [   04]   BAM_TIMER_IRQ                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   BAM_EMPTY_IRQ                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_ERROR_IRQ                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_HRESP_ERR_IRQ                        = "  "0,1"
        textline ""
      tree.end
      tree "BAM_IRQ_CLR"
        group.long 0x18--0x1B "BAM_IRQ_CLR (at 0xFC834018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x4 " [   04]   BAM_TIMER_CLR                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   BAM_EMPTY_CLR                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_ERROR_CLR                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_HRESP_ERR_CLR                        = "  "0,1"
        textline ""
      tree.end
      tree "BAM_IRQ_EN"
        group.long 0x1C--0x1F "BAM_IRQ_EN (at 0xFC83401C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x4 " [   04]   BAM_TIMER_EN                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   BAM_EMPTY_EN                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_ERROR_EN                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_HRESP_ERR_EN                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_AHB_MASTER_ERR_CTRLS"
        group.long 0x24--0x27 "BAM_AHB_MASTER_ERR_CTRLS (at 0xFC834024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x12--0x16 1  " [22:18]   BAM_ERR_HVMID                            = " 
        textline ""
        bitfld.long 0x0 0x11 " [   17]   BAM_ERR_DIRECT_MODE                      = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0xC--0x10 1  " [16:12]   BAM_ERR_HCID                             = " 
        textline ""
        hexmask.long.word 0x0 0x8--0xB 1  " [11:08]   BAM_ERR_HPROT                            = " 
        textline ""
        bitfld.long 0x0 0x5--0x7 " [07:05]   BAM_ERR_HBURST                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x3--0x4 " [04:03]   BAM_ERR_HSIZE                            = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_ERR_HWRITE                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0--0x1 " [01:00]   BAM_ERR_HTRANS                           = "  "0,1,2,3"
        textline ""
      tree.end
      tree "BAM_AHB_MASTER_ERR_ADDR"
        group.long 0x28--0x2B "BAM_AHB_MASTER_ERR_ADDR (at 0xFC834028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   BAM_ERR_ADDR                             = " 
        textline ""
      tree.end
      tree "BAM_AHB_MASTER_ERR_DATA"
        group.long 0x2C--0x2F "BAM_AHB_MASTER_ERR_DATA (at 0xFC83402C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   BAM_ERR_DATA                             = " 
        textline ""
      tree.end
      tree "BAM_TRUST_REG"
        group.long 0x70--0x73 "BAM_TRUST_REG (at 0xFC834070) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0xD " [   13]   LOCK_EE_CTRL                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_VMID                                 = " 
        textline ""
        bitfld.long 0x0 0x7 " [   07]   BAM_RST_BLOCK                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_EE                                   = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_TEST_BUS_SEL"
        group.long 0x74--0x77 "BAM_TEST_BUS_SEL (at 0xFC834074) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x15 " [   21]   SW_EVENTS_ZERO                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x13--0x14 " [20:19]   SW_EVENTS_SEL                            = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x12 " [   18]   BAM_DATA_ERASE                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11 " [   17]   BAM_DATA_FLUSH                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   BAM_CLK_ALWAYS_ON                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x0--0x6 1  " [06:00]   BAM_TESTBUS_SEL                          = " 
        textline ""
      tree.end
      tree "BAM_TEST_BUS_REG"
        group.long 0x78--0x7B "BAM_TEST_BUS_REG (at 0xFC834078) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   BAM_TESTBUS_REG                          = " 
        textline ""
      tree.end
      tree "BAM_CNFG_BITS"
        group.long 0x7C--0x7F "BAM_CNFG_BITS (at 0xFC83407C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1E " [   30]   MULTIPLE_EVENTS_DESC_AVAIL_EN            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   MULTIPLE_EVENTS_SIZE_EN                  = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1C " [   28]   BAM_ZLT_W_CD_SUPPORT                     = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1B " [   27]   BAM_CD_ENABLE                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1A " [   26]   BAM_AU_ACCUMED                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x19 " [   25]   BAM_PSM_P_HD_DATA                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_REG_P_EN                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_WB_DSC_AVL_P_RST                     = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_WB_RETR_SVPNT                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_WB_CSW_ACK_IDL                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_WB_BLK_CSW                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x13 " [   19]   BAM_WB_P_RES                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x12 " [   18]   BAM_SI_P_RES                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11 " [   17]   BAM_AU_P_RES                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   BAM_PSM_P_RES                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0xF " [   15]   BAM_PSM_CSW_REQ                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0xE " [   14]   BAM_SB_CLK_REQ                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0xD " [   13]   BAM_IBC_DISABLE                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0xC " [   12]   BAM_NO_EXT_P_RST                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0xB " [   11]   BAM_FULL_PIPE                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   BAM_ADML_SYNC_BRIDGE                     = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_PIPE_CNFG                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_ADML_DEEP_CONS_FIFO                  = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   BAM_ADML_INCR4_EN_N                      = "  "0,1"
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE0"
        group.long 0x800--0x803 "BAM_IRQ_SRCS_EE0 (at 0xFC834800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE1"
        group.long 0x880--0x883 "BAM_IRQ_SRCS_EE1 (at 0xFC834880) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE2"
        group.long 0x900--0x903 "BAM_IRQ_SRCS_EE2 (at 0xFC834900) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE3"
        group.long 0x980--0x983 "BAM_IRQ_SRCS_EE3 (at 0xFC834980) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE4"
        group.long 0xA00--0xA03 "BAM_IRQ_SRCS_EE4 (at 0xFC834A00) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE5"
        group.long 0xA80--0xA83 "BAM_IRQ_SRCS_EE5 (at 0xFC834A80) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE6"
        group.long 0xB00--0xB03 "BAM_IRQ_SRCS_EE6 (at 0xFC834B00) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE7"
        group.long 0xB80--0xB83 "BAM_IRQ_SRCS_EE7 (at 0xFC834B80) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE0"
        group.long 0x804--0x807 "BAM_IRQ_SRCS_MSK_EE0 (at 0xFC834804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE1"
        group.long 0x884--0x887 "BAM_IRQ_SRCS_MSK_EE1 (at 0xFC834884) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE2"
        group.long 0x904--0x907 "BAM_IRQ_SRCS_MSK_EE2 (at 0xFC834904) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE3"
        group.long 0x984--0x987 "BAM_IRQ_SRCS_MSK_EE3 (at 0xFC834984) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE4"
        group.long 0xA04--0xA07 "BAM_IRQ_SRCS_MSK_EE4 (at 0xFC834A04) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE5"
        group.long 0xA84--0xA87 "BAM_IRQ_SRCS_MSK_EE5 (at 0xFC834A84) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE6"
        group.long 0xB04--0xB07 "BAM_IRQ_SRCS_MSK_EE6 (at 0xFC834B04) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE7"
        group.long 0xB84--0xB87 "BAM_IRQ_SRCS_MSK_EE7 (at 0xFC834B84) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE0"
        group.long 0x808--0x80B "BAM_IRQ_SRCS_UNMASKED_EE0 (at 0xFC834808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE1"
        group.long 0x888--0x88B "BAM_IRQ_SRCS_UNMASKED_EE1 (at 0xFC834888) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE2"
        group.long 0x908--0x90B "BAM_IRQ_SRCS_UNMASKED_EE2 (at 0xFC834908) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE3"
        group.long 0x988--0x98B "BAM_IRQ_SRCS_UNMASKED_EE3 (at 0xFC834988) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE4"
        group.long 0xA08--0xA0B "BAM_IRQ_SRCS_UNMASKED_EE4 (at 0xFC834A08) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE5"
        group.long 0xA88--0xA8B "BAM_IRQ_SRCS_UNMASKED_EE5 (at 0xFC834A88) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE6"
        group.long 0xB08--0xB0B "BAM_IRQ_SRCS_UNMASKED_EE6 (at 0xFC834B08) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE7"
        group.long 0xB88--0xB8B "BAM_IRQ_SRCS_UNMASKED_EE7 (at 0xFC834B88) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
;End of BAM Control Registers
tree.end
tree "Pipe 0"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL0"
        group.long 0x1000--0x1003 "BAM_P_CTRL0 (at 0xFC835000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST0"
        group.long 0x1004--0x1007 "BAM_P_RST0 (at 0xFC835004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT0"
        group.long 0x1008--0x100B "BAM_P_HALT0 (at 0xFC835008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG0"
        group.long 0x1030--0x1033 "BAM_P_TRUST_REG0 (at 0xFC835030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS0"
        group.long 0x1010--0x1013 "BAM_P_IRQ_STTS0 (at 0xFC835010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR0"
        group.long 0x1014--0x1017 "BAM_P_IRQ_CLR0 (at 0xFC835014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN0"
        group.long 0x1018--0x101B "BAM_P_IRQ_EN0 (at 0xFC835018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER0"
        group.long 0x101C--0x101F "BAM_P_TIMER0 (at 0xFC83501C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL0"
        group.long 0x1020--0x1023 "BAM_P_TIMER_CTRL0 (at 0xFC835020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND0"
        group.long 0x1024--0x1027 "BAM_P_PRDCR_SDBND0 (at 0xFC835024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND0"
        group.long 0x1028--0x102B "BAM_P_CNSMR_SDBND0 (at 0xFC835028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR0"
        group.long 0x182C--0x182F "BAM_P_EVNT_DEST_ADDR0 (at 0xFC83582C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG0"
        group.long 0x1818--0x181B "BAM_P_EVNT_REG0 (at 0xFC835818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS0"
        group.long 0x1800--0x1803 "BAM_P_SW_OFSTS0 (at 0xFC835800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR0"
        group.long 0x1824--0x1827 "BAM_P_DATA_FIFO_ADDR0 (at 0xFC835824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR0"
        group.long 0x181C--0x181F "BAM_P_DESC_FIFO_ADDR0 (at 0xFC83581C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD0"
        group.long 0x1828--0x182B "BAM_P_EVNT_GEN_TRSHLD0 (at 0xFC835828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES0"
        group.long 0x1820--0x1823 "BAM_P_FIFO_SIZES0 (at 0xFC835820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_0"
        group.long 0x1834--0x1837 "BAM_P_RETR_CNTXT_0 (at 0xFC835834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_0"
        group.long 0x1838--0x183B "BAM_P_SI_CNTXT_0 (at 0xFC835838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_0"
        group.long 0x1830--0x1833 "BAM_P_DF_CNTXT_0 (at 0xFC835830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_0"
        group.long 0x1804--0x1807 "BAM_P_AU_PSM_CNTXT_1_0 (at 0xFC835804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_0"
        group.long 0x1808--0x180B "BAM_P_PSM_CNTXT_2_0 (at 0xFC835808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_0"
        group.long 0x180C--0x180F "BAM_P_PSM_CNTXT_3_0 (at 0xFC83580C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_0"
        group.long 0x1810--0x1813 "BAM_P_PSM_CNTXT_4_0 (at 0xFC835810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_0"
        group.long 0x1814--0x1817 "BAM_P_PSM_CNTXT_5_0 (at 0xFC835814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 0
tree.end
tree "Pipe 1"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL1"
        group.long 0x2000--0x2003 "BAM_P_CTRL1 (at 0xFC836000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST1"
        group.long 0x2004--0x2007 "BAM_P_RST1 (at 0xFC836004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT1"
        group.long 0x2008--0x200B "BAM_P_HALT1 (at 0xFC836008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG1"
        group.long 0x2030--0x2033 "BAM_P_TRUST_REG1 (at 0xFC836030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS1"
        group.long 0x2010--0x2013 "BAM_P_IRQ_STTS1 (at 0xFC836010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR1"
        group.long 0x2014--0x2017 "BAM_P_IRQ_CLR1 (at 0xFC836014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN1"
        group.long 0x2018--0x201B "BAM_P_IRQ_EN1 (at 0xFC836018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER1"
        group.long 0x201C--0x201F "BAM_P_TIMER1 (at 0xFC83601C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL1"
        group.long 0x2020--0x2023 "BAM_P_TIMER_CTRL1 (at 0xFC836020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND1"
        group.long 0x2024--0x2027 "BAM_P_PRDCR_SDBND1 (at 0xFC836024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND1"
        group.long 0x2028--0x202B "BAM_P_CNSMR_SDBND1 (at 0xFC836028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR1"
        group.long 0x282C--0x282F "BAM_P_EVNT_DEST_ADDR1 (at 0xFC83682C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG1"
        group.long 0x2818--0x281B "BAM_P_EVNT_REG1 (at 0xFC836818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS1"
        group.long 0x2800--0x2803 "BAM_P_SW_OFSTS1 (at 0xFC836800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR1"
        group.long 0x2824--0x2827 "BAM_P_DATA_FIFO_ADDR1 (at 0xFC836824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR1"
        group.long 0x281C--0x281F "BAM_P_DESC_FIFO_ADDR1 (at 0xFC83681C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD1"
        group.long 0x2828--0x282B "BAM_P_EVNT_GEN_TRSHLD1 (at 0xFC836828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES1"
        group.long 0x2820--0x2823 "BAM_P_FIFO_SIZES1 (at 0xFC836820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_1"
        group.long 0x2834--0x2837 "BAM_P_RETR_CNTXT_1 (at 0xFC836834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_1"
        group.long 0x2838--0x283B "BAM_P_SI_CNTXT_1 (at 0xFC836838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_1"
        group.long 0x2830--0x2833 "BAM_P_DF_CNTXT_1 (at 0xFC836830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_1"
        group.long 0x2804--0x2807 "BAM_P_AU_PSM_CNTXT_1_1 (at 0xFC836804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_1"
        group.long 0x2808--0x280B "BAM_P_PSM_CNTXT_2_1 (at 0xFC836808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_1"
        group.long 0x280C--0x280F "BAM_P_PSM_CNTXT_3_1 (at 0xFC83680C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_1"
        group.long 0x2810--0x2813 "BAM_P_PSM_CNTXT_4_1 (at 0xFC836810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_1"
        group.long 0x2814--0x2817 "BAM_P_PSM_CNTXT_5_1 (at 0xFC836814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 1
tree.end
tree "Pipe 2"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL2"
        group.long 0x3000--0x3003 "BAM_P_CTRL2 (at 0xFC837000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST2"
        group.long 0x3004--0x3007 "BAM_P_RST2 (at 0xFC837004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT2"
        group.long 0x3008--0x300B "BAM_P_HALT2 (at 0xFC837008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG2"
        group.long 0x3030--0x3033 "BAM_P_TRUST_REG2 (at 0xFC837030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS2"
        group.long 0x3010--0x3013 "BAM_P_IRQ_STTS2 (at 0xFC837010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR2"
        group.long 0x3014--0x3017 "BAM_P_IRQ_CLR2 (at 0xFC837014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN2"
        group.long 0x3018--0x301B "BAM_P_IRQ_EN2 (at 0xFC837018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER2"
        group.long 0x301C--0x301F "BAM_P_TIMER2 (at 0xFC83701C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL2"
        group.long 0x3020--0x3023 "BAM_P_TIMER_CTRL2 (at 0xFC837020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND2"
        group.long 0x3024--0x3027 "BAM_P_PRDCR_SDBND2 (at 0xFC837024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND2"
        group.long 0x3028--0x302B "BAM_P_CNSMR_SDBND2 (at 0xFC837028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR2"
        group.long 0x382C--0x382F "BAM_P_EVNT_DEST_ADDR2 (at 0xFC83782C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG2"
        group.long 0x3818--0x381B "BAM_P_EVNT_REG2 (at 0xFC837818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS2"
        group.long 0x3800--0x3803 "BAM_P_SW_OFSTS2 (at 0xFC837800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR2"
        group.long 0x3824--0x3827 "BAM_P_DATA_FIFO_ADDR2 (at 0xFC837824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR2"
        group.long 0x381C--0x381F "BAM_P_DESC_FIFO_ADDR2 (at 0xFC83781C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD2"
        group.long 0x3828--0x382B "BAM_P_EVNT_GEN_TRSHLD2 (at 0xFC837828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES2"
        group.long 0x3820--0x3823 "BAM_P_FIFO_SIZES2 (at 0xFC837820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_2"
        group.long 0x3834--0x3837 "BAM_P_RETR_CNTXT_2 (at 0xFC837834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_2"
        group.long 0x3838--0x383B "BAM_P_SI_CNTXT_2 (at 0xFC837838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_2"
        group.long 0x3830--0x3833 "BAM_P_DF_CNTXT_2 (at 0xFC837830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_2"
        group.long 0x3804--0x3807 "BAM_P_AU_PSM_CNTXT_1_2 (at 0xFC837804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_2"
        group.long 0x3808--0x380B "BAM_P_PSM_CNTXT_2_2 (at 0xFC837808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_2"
        group.long 0x380C--0x380F "BAM_P_PSM_CNTXT_3_2 (at 0xFC83780C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_2"
        group.long 0x3810--0x3813 "BAM_P_PSM_CNTXT_4_2 (at 0xFC837810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_2"
        group.long 0x3814--0x3817 "BAM_P_PSM_CNTXT_5_2 (at 0xFC837814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 2
tree.end
tree "Pipe 3"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL3"
        group.long 0x4000--0x4003 "BAM_P_CTRL3 (at 0xFC838000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST3"
        group.long 0x4004--0x4007 "BAM_P_RST3 (at 0xFC838004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT3"
        group.long 0x4008--0x400B "BAM_P_HALT3 (at 0xFC838008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG3"
        group.long 0x4030--0x4033 "BAM_P_TRUST_REG3 (at 0xFC838030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS3"
        group.long 0x4010--0x4013 "BAM_P_IRQ_STTS3 (at 0xFC838010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR3"
        group.long 0x4014--0x4017 "BAM_P_IRQ_CLR3 (at 0xFC838014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN3"
        group.long 0x4018--0x401B "BAM_P_IRQ_EN3 (at 0xFC838018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER3"
        group.long 0x401C--0x401F "BAM_P_TIMER3 (at 0xFC83801C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL3"
        group.long 0x4020--0x4023 "BAM_P_TIMER_CTRL3 (at 0xFC838020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND3"
        group.long 0x4024--0x4027 "BAM_P_PRDCR_SDBND3 (at 0xFC838024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND3"
        group.long 0x4028--0x402B "BAM_P_CNSMR_SDBND3 (at 0xFC838028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR3"
        group.long 0x482C--0x482F "BAM_P_EVNT_DEST_ADDR3 (at 0xFC83882C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG3"
        group.long 0x4818--0x481B "BAM_P_EVNT_REG3 (at 0xFC838818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS3"
        group.long 0x4800--0x4803 "BAM_P_SW_OFSTS3 (at 0xFC838800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR3"
        group.long 0x4824--0x4827 "BAM_P_DATA_FIFO_ADDR3 (at 0xFC838824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR3"
        group.long 0x481C--0x481F "BAM_P_DESC_FIFO_ADDR3 (at 0xFC83881C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD3"
        group.long 0x4828--0x482B "BAM_P_EVNT_GEN_TRSHLD3 (at 0xFC838828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES3"
        group.long 0x4820--0x4823 "BAM_P_FIFO_SIZES3 (at 0xFC838820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_3"
        group.long 0x4834--0x4837 "BAM_P_RETR_CNTXT_3 (at 0xFC838834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_3"
        group.long 0x4838--0x483B "BAM_P_SI_CNTXT_3 (at 0xFC838838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_3"
        group.long 0x4830--0x4833 "BAM_P_DF_CNTXT_3 (at 0xFC838830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_3"
        group.long 0x4804--0x4807 "BAM_P_AU_PSM_CNTXT_1_3 (at 0xFC838804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_3"
        group.long 0x4808--0x480B "BAM_P_PSM_CNTXT_2_3 (at 0xFC838808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_3"
        group.long 0x480C--0x480F "BAM_P_PSM_CNTXT_3_3 (at 0xFC83880C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_3"
        group.long 0x4810--0x4813 "BAM_P_PSM_CNTXT_4_3 (at 0xFC838810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_3"
        group.long 0x4814--0x4817 "BAM_P_PSM_CNTXT_5_3 (at 0xFC838814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 3
tree.end
tree "Pipe 4"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL4"
        group.long 0x5000--0x5003 "BAM_P_CTRL4 (at 0xFC839000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST4"
        group.long 0x5004--0x5007 "BAM_P_RST4 (at 0xFC839004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT4"
        group.long 0x5008--0x500B "BAM_P_HALT4 (at 0xFC839008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG4"
        group.long 0x5030--0x5033 "BAM_P_TRUST_REG4 (at 0xFC839030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS4"
        group.long 0x5010--0x5013 "BAM_P_IRQ_STTS4 (at 0xFC839010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR4"
        group.long 0x5014--0x5017 "BAM_P_IRQ_CLR4 (at 0xFC839014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN4"
        group.long 0x5018--0x501B "BAM_P_IRQ_EN4 (at 0xFC839018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER4"
        group.long 0x501C--0x501F "BAM_P_TIMER4 (at 0xFC83901C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL4"
        group.long 0x5020--0x5023 "BAM_P_TIMER_CTRL4 (at 0xFC839020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND4"
        group.long 0x5024--0x5027 "BAM_P_PRDCR_SDBND4 (at 0xFC839024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND4"
        group.long 0x5028--0x502B "BAM_P_CNSMR_SDBND4 (at 0xFC839028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR4"
        group.long 0x582C--0x582F "BAM_P_EVNT_DEST_ADDR4 (at 0xFC83982C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG4"
        group.long 0x5818--0x581B "BAM_P_EVNT_REG4 (at 0xFC839818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS4"
        group.long 0x5800--0x5803 "BAM_P_SW_OFSTS4 (at 0xFC839800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR4"
        group.long 0x5824--0x5827 "BAM_P_DATA_FIFO_ADDR4 (at 0xFC839824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR4"
        group.long 0x581C--0x581F "BAM_P_DESC_FIFO_ADDR4 (at 0xFC83981C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD4"
        group.long 0x5828--0x582B "BAM_P_EVNT_GEN_TRSHLD4 (at 0xFC839828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES4"
        group.long 0x5820--0x5823 "BAM_P_FIFO_SIZES4 (at 0xFC839820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_4"
        group.long 0x5834--0x5837 "BAM_P_RETR_CNTXT_4 (at 0xFC839834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_4"
        group.long 0x5838--0x583B "BAM_P_SI_CNTXT_4 (at 0xFC839838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_4"
        group.long 0x5830--0x5833 "BAM_P_DF_CNTXT_4 (at 0xFC839830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_4"
        group.long 0x5804--0x5807 "BAM_P_AU_PSM_CNTXT_1_4 (at 0xFC839804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_4"
        group.long 0x5808--0x580B "BAM_P_PSM_CNTXT_2_4 (at 0xFC839808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_4"
        group.long 0x580C--0x580F "BAM_P_PSM_CNTXT_3_4 (at 0xFC83980C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_4"
        group.long 0x5810--0x5813 "BAM_P_PSM_CNTXT_4_4 (at 0xFC839810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_4"
        group.long 0x5814--0x5817 "BAM_P_PSM_CNTXT_5_4 (at 0xFC839814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 4
tree.end
tree "Pipe 5"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL5"
        group.long 0x6000--0x6003 "BAM_P_CTRL5 (at 0xFC83A000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST5"
        group.long 0x6004--0x6007 "BAM_P_RST5 (at 0xFC83A004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT5"
        group.long 0x6008--0x600B "BAM_P_HALT5 (at 0xFC83A008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG5"
        group.long 0x6030--0x6033 "BAM_P_TRUST_REG5 (at 0xFC83A030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS5"
        group.long 0x6010--0x6013 "BAM_P_IRQ_STTS5 (at 0xFC83A010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR5"
        group.long 0x6014--0x6017 "BAM_P_IRQ_CLR5 (at 0xFC83A014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN5"
        group.long 0x6018--0x601B "BAM_P_IRQ_EN5 (at 0xFC83A018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER5"
        group.long 0x601C--0x601F "BAM_P_TIMER5 (at 0xFC83A01C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL5"
        group.long 0x6020--0x6023 "BAM_P_TIMER_CTRL5 (at 0xFC83A020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND5"
        group.long 0x6024--0x6027 "BAM_P_PRDCR_SDBND5 (at 0xFC83A024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND5"
        group.long 0x6028--0x602B "BAM_P_CNSMR_SDBND5 (at 0xFC83A028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR5"
        group.long 0x682C--0x682F "BAM_P_EVNT_DEST_ADDR5 (at 0xFC83A82C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG5"
        group.long 0x6818--0x681B "BAM_P_EVNT_REG5 (at 0xFC83A818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS5"
        group.long 0x6800--0x6803 "BAM_P_SW_OFSTS5 (at 0xFC83A800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR5"
        group.long 0x6824--0x6827 "BAM_P_DATA_FIFO_ADDR5 (at 0xFC83A824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR5"
        group.long 0x681C--0x681F "BAM_P_DESC_FIFO_ADDR5 (at 0xFC83A81C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD5"
        group.long 0x6828--0x682B "BAM_P_EVNT_GEN_TRSHLD5 (at 0xFC83A828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES5"
        group.long 0x6820--0x6823 "BAM_P_FIFO_SIZES5 (at 0xFC83A820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_5"
        group.long 0x6834--0x6837 "BAM_P_RETR_CNTXT_5 (at 0xFC83A834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_5"
        group.long 0x6838--0x683B "BAM_P_SI_CNTXT_5 (at 0xFC83A838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_5"
        group.long 0x6830--0x6833 "BAM_P_DF_CNTXT_5 (at 0xFC83A830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_5"
        group.long 0x6804--0x6807 "BAM_P_AU_PSM_CNTXT_1_5 (at 0xFC83A804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_5"
        group.long 0x6808--0x680B "BAM_P_PSM_CNTXT_2_5 (at 0xFC83A808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_5"
        group.long 0x680C--0x680F "BAM_P_PSM_CNTXT_3_5 (at 0xFC83A80C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_5"
        group.long 0x6810--0x6813 "BAM_P_PSM_CNTXT_4_5 (at 0xFC83A810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_5"
        group.long 0x6814--0x6817 "BAM_P_PSM_CNTXT_5_5 (at 0xFC83A814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 5
tree.end
tree.end
;Block Per Data Ends

base ad:0xFC9C4000
tree "MSS_Crypto"
tree "BAM Control Registers"
      tree "BAM_CTRL"
        group.long 0x0--0x3 "BAM_CTRL (at 0xFC9C4000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x13 " [   19]   CACHE_MISS_ERR_RESP_EN                   = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11--0x12 " [18:17]   LOCAL_CLK_GATING                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   IBC_DISABLE                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0xF " [   15]   BAM_CACHED_DESC_STORE                    = "  "0,1"
        textline ""
        bitfld.long 0x0 0xD--0xE " [14:13]   BAM_DESC_CACHE_SEL                       = "  "0,1,2,3"
        textline ""
        hexmask.long.word 0x0 0x5--0xB 1  " [11:05]   BAM_TESTBUS_SEL                          = " 
        textline ""
        bitfld.long 0x0 0x4 " [   04]   BAM_EN_ACCUM                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_EN                                   = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   BAM_SW_RST                               = "  "0,1"
        textline ""
      tree.end
      tree "BAM_REVISION"
        group.long 0x4--0x7 "BAM_REVISION (at 0xFC9C4004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x18--0x1F 1  " [31:24]   INACTIV_TMR_BASE                         = " 
        textline ""
        bitfld.long 0x0 0x17 " [   23]   CMD_DESC_EN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15--0x16 " [22:21]   DESC_CACHE_DEPTH                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   NUM_INACTIV_TMRS                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x13 " [   19]   INACTIV_TMRS_EXST                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x12 " [   18]   HIGH_FREQUENCY_BAM                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11 " [   17]   BAM_HAS_NO_BYPASS                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   SECURED                                  = "  "0,1"
        textline ""
        bitfld.long 0x0 0xF " [   15]   USE_VMIDMT                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0xE " [   14]   AXI_ACTIVE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0xD " [   13]   CE_BUFFER_SIZE                           = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x8--0xB 1  " [11:08]   NUM_EES                                  = " 
        textline ""
        hexmask.long.word 0x0 0x0--0x7 1  " [07:00]   REVISION                                 = " 
        textline ""
      tree.end
      tree "BAM_SW_VERSION"
        group.long 0x80--0x83 "BAM_SW_VERSION (at 0xFC9C4080) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x1C--0x1F 1  " [31:28]   MAJOR                                    = " 
        textline ""
        hexmask.long.word 0x0 0x10--0x1B 1  " [27:16]   MINOR                                    = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   STEP                                     = " 
        textline ""
      tree.end
      tree "BAM_NUM_PIPES"
        group.long 0x3C--0x3F "BAM_NUM_PIPES (at 0xFC9C403C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x18--0x1F 1  " [31:24]   BAM_NON_PIPE_GRP                         = " 
        textline ""
        hexmask.long.word 0x0 0x10--0x17 1  " [23:16]   PERIPH_NON_PIPE_GRP                      = " 
        textline ""
        hexmask.long.word 0x0 0x0--0x7 1  " [07:00]   BAM_NUM_PIPES                            = " 
        textline ""
      tree.end
      tree "BAM_TIMER"
        group.long 0x40--0x43 "BAM_TIMER (at 0xFC9C4040) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   TIMER                                    = " 
        textline ""
      tree.end
      tree "BAM_TIMER_CTRL"
        group.long 0x44--0x47 "BAM_TIMER_CTRL (at 0xFC9C4044) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   TIMER_RST                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   TIMER_RUN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   TIMER_MODE                               = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   TIMER_TRSHLD                             = " 
        textline ""
      tree.end
      tree "BAM_DESC_CNT_TRSHLD"
        group.long 0x8--0xB "BAM_DESC_CNT_TRSHLD (at 0xFC9C4008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   CNT_TRSHLD                               = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS"
        group.long 0xC--0xF "BAM_IRQ_SRCS (at 0xFC9C400C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK"
        group.long 0x10--0x13 "BAM_IRQ_SRCS_MSK (at 0xFC9C4010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED"
        group.long 0x30--0x33 "BAM_IRQ_SRCS_UNMASKED (at 0xFC9C4030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_STTS"
        group.long 0x14--0x17 "BAM_IRQ_STTS (at 0xFC9C4014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x4 " [   04]   BAM_TIMER_IRQ                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   BAM_EMPTY_IRQ                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_ERROR_IRQ                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_HRESP_ERR_IRQ                        = "  "0,1"
        textline ""
      tree.end
      tree "BAM_IRQ_CLR"
        group.long 0x18--0x1B "BAM_IRQ_CLR (at 0xFC9C4018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x4 " [   04]   BAM_TIMER_CLR                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   BAM_EMPTY_CLR                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_ERROR_CLR                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_HRESP_ERR_CLR                        = "  "0,1"
        textline ""
      tree.end
      tree "BAM_IRQ_EN"
        group.long 0x1C--0x1F "BAM_IRQ_EN (at 0xFC9C401C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x4 " [   04]   BAM_TIMER_EN                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   BAM_EMPTY_EN                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_ERROR_EN                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_HRESP_ERR_EN                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_AHB_MASTER_ERR_CTRLS"
        group.long 0x24--0x27 "BAM_AHB_MASTER_ERR_CTRLS (at 0xFC9C4024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x12--0x16 1  " [22:18]   BAM_ERR_HVMID                            = " 
        textline ""
        bitfld.long 0x0 0x11 " [   17]   BAM_ERR_DIRECT_MODE                      = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0xC--0x10 1  " [16:12]   BAM_ERR_HCID                             = " 
        textline ""
        hexmask.long.word 0x0 0x8--0xB 1  " [11:08]   BAM_ERR_HPROT                            = " 
        textline ""
        bitfld.long 0x0 0x5--0x7 " [07:05]   BAM_ERR_HBURST                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x3--0x4 " [04:03]   BAM_ERR_HSIZE                            = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_ERR_HWRITE                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0--0x1 " [01:00]   BAM_ERR_HTRANS                           = "  "0,1,2,3"
        textline ""
      tree.end
      tree "BAM_AHB_MASTER_ERR_ADDR"
        group.long 0x28--0x2B "BAM_AHB_MASTER_ERR_ADDR (at 0xFC9C4028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   BAM_ERR_ADDR                             = " 
        textline ""
      tree.end
      tree "BAM_AHB_MASTER_ERR_DATA"
        group.long 0x2C--0x2F "BAM_AHB_MASTER_ERR_DATA (at 0xFC9C402C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   BAM_ERR_DATA                             = " 
        textline ""
      tree.end
      tree "BAM_TRUST_REG"
        group.long 0x70--0x73 "BAM_TRUST_REG (at 0xFC9C4070) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0xD " [   13]   LOCK_EE_CTRL                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_VMID                                 = " 
        textline ""
        bitfld.long 0x0 0x7 " [   07]   BAM_RST_BLOCK                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_EE                                   = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_TEST_BUS_SEL"
        group.long 0x74--0x77 "BAM_TEST_BUS_SEL (at 0xFC9C4074) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x15 " [   21]   SW_EVENTS_ZERO                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x13--0x14 " [20:19]   SW_EVENTS_SEL                            = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x12 " [   18]   BAM_DATA_ERASE                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11 " [   17]   BAM_DATA_FLUSH                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   BAM_CLK_ALWAYS_ON                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x0--0x6 1  " [06:00]   BAM_TESTBUS_SEL                          = " 
        textline ""
      tree.end
      tree "BAM_TEST_BUS_REG"
        group.long 0x78--0x7B "BAM_TEST_BUS_REG (at 0xFC9C4078) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   BAM_TESTBUS_REG                          = " 
        textline ""
      tree.end
      tree "BAM_CNFG_BITS"
        group.long 0x7C--0x7F "BAM_CNFG_BITS (at 0xFC9C407C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1E " [   30]   MULTIPLE_EVENTS_DESC_AVAIL_EN            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   MULTIPLE_EVENTS_SIZE_EN                  = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1C " [   28]   BAM_ZLT_W_CD_SUPPORT                     = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1B " [   27]   BAM_CD_ENABLE                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1A " [   26]   BAM_AU_ACCUMED                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x19 " [   25]   BAM_PSM_P_HD_DATA                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_REG_P_EN                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_WB_DSC_AVL_P_RST                     = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_WB_RETR_SVPNT                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_WB_CSW_ACK_IDL                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_WB_BLK_CSW                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x13 " [   19]   BAM_WB_P_RES                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x12 " [   18]   BAM_SI_P_RES                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11 " [   17]   BAM_AU_P_RES                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   BAM_PSM_P_RES                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0xF " [   15]   BAM_PSM_CSW_REQ                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0xE " [   14]   BAM_SB_CLK_REQ                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0xD " [   13]   BAM_IBC_DISABLE                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0xC " [   12]   BAM_NO_EXT_P_RST                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0xB " [   11]   BAM_FULL_PIPE                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   BAM_ADML_SYNC_BRIDGE                     = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_PIPE_CNFG                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_ADML_DEEP_CONS_FIFO                  = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   BAM_ADML_INCR4_EN_N                      = "  "0,1"
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE0"
        group.long 0x800--0x803 "BAM_IRQ_SRCS_EE0 (at 0xFC9C4800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE1"
        group.long 0x880--0x883 "BAM_IRQ_SRCS_EE1 (at 0xFC9C4880) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE2"
        group.long 0x900--0x903 "BAM_IRQ_SRCS_EE2 (at 0xFC9C4900) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE3"
        group.long 0x980--0x983 "BAM_IRQ_SRCS_EE3 (at 0xFC9C4980) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE4"
        group.long 0xA00--0xA03 "BAM_IRQ_SRCS_EE4 (at 0xFC9C4A00) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE5"
        group.long 0xA80--0xA83 "BAM_IRQ_SRCS_EE5 (at 0xFC9C4A80) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE6"
        group.long 0xB00--0xB03 "BAM_IRQ_SRCS_EE6 (at 0xFC9C4B00) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE7"
        group.long 0xB80--0xB83 "BAM_IRQ_SRCS_EE7 (at 0xFC9C4B80) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE0"
        group.long 0x804--0x807 "BAM_IRQ_SRCS_MSK_EE0 (at 0xFC9C4804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE1"
        group.long 0x884--0x887 "BAM_IRQ_SRCS_MSK_EE1 (at 0xFC9C4884) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE2"
        group.long 0x904--0x907 "BAM_IRQ_SRCS_MSK_EE2 (at 0xFC9C4904) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE3"
        group.long 0x984--0x987 "BAM_IRQ_SRCS_MSK_EE3 (at 0xFC9C4984) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE4"
        group.long 0xA04--0xA07 "BAM_IRQ_SRCS_MSK_EE4 (at 0xFC9C4A04) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE5"
        group.long 0xA84--0xA87 "BAM_IRQ_SRCS_MSK_EE5 (at 0xFC9C4A84) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE6"
        group.long 0xB04--0xB07 "BAM_IRQ_SRCS_MSK_EE6 (at 0xFC9C4B04) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE7"
        group.long 0xB84--0xB87 "BAM_IRQ_SRCS_MSK_EE7 (at 0xFC9C4B84) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE0"
        group.long 0x808--0x80B "BAM_IRQ_SRCS_UNMASKED_EE0 (at 0xFC9C4808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE1"
        group.long 0x888--0x88B "BAM_IRQ_SRCS_UNMASKED_EE1 (at 0xFC9C4888) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE2"
        group.long 0x908--0x90B "BAM_IRQ_SRCS_UNMASKED_EE2 (at 0xFC9C4908) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE3"
        group.long 0x988--0x98B "BAM_IRQ_SRCS_UNMASKED_EE3 (at 0xFC9C4988) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE4"
        group.long 0xA08--0xA0B "BAM_IRQ_SRCS_UNMASKED_EE4 (at 0xFC9C4A08) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE5"
        group.long 0xA88--0xA8B "BAM_IRQ_SRCS_UNMASKED_EE5 (at 0xFC9C4A88) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE6"
        group.long 0xB08--0xB0B "BAM_IRQ_SRCS_UNMASKED_EE6 (at 0xFC9C4B08) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE7"
        group.long 0xB88--0xB8B "BAM_IRQ_SRCS_UNMASKED_EE7 (at 0xFC9C4B88) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
;End of BAM Control Registers
tree.end
tree "Pipe 0"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL0"
        group.long 0x1000--0x1003 "BAM_P_CTRL0 (at 0xFC9C5000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST0"
        group.long 0x1004--0x1007 "BAM_P_RST0 (at 0xFC9C5004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT0"
        group.long 0x1008--0x100B "BAM_P_HALT0 (at 0xFC9C5008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG0"
        group.long 0x1030--0x1033 "BAM_P_TRUST_REG0 (at 0xFC9C5030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS0"
        group.long 0x1010--0x1013 "BAM_P_IRQ_STTS0 (at 0xFC9C5010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR0"
        group.long 0x1014--0x1017 "BAM_P_IRQ_CLR0 (at 0xFC9C5014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN0"
        group.long 0x1018--0x101B "BAM_P_IRQ_EN0 (at 0xFC9C5018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER0"
        group.long 0x101C--0x101F "BAM_P_TIMER0 (at 0xFC9C501C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL0"
        group.long 0x1020--0x1023 "BAM_P_TIMER_CTRL0 (at 0xFC9C5020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND0"
        group.long 0x1024--0x1027 "BAM_P_PRDCR_SDBND0 (at 0xFC9C5024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND0"
        group.long 0x1028--0x102B "BAM_P_CNSMR_SDBND0 (at 0xFC9C5028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR0"
        group.long 0x182C--0x182F "BAM_P_EVNT_DEST_ADDR0 (at 0xFC9C582C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG0"
        group.long 0x1818--0x181B "BAM_P_EVNT_REG0 (at 0xFC9C5818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS0"
        group.long 0x1800--0x1803 "BAM_P_SW_OFSTS0 (at 0xFC9C5800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR0"
        group.long 0x1824--0x1827 "BAM_P_DATA_FIFO_ADDR0 (at 0xFC9C5824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR0"
        group.long 0x181C--0x181F "BAM_P_DESC_FIFO_ADDR0 (at 0xFC9C581C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD0"
        group.long 0x1828--0x182B "BAM_P_EVNT_GEN_TRSHLD0 (at 0xFC9C5828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES0"
        group.long 0x1820--0x1823 "BAM_P_FIFO_SIZES0 (at 0xFC9C5820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_0"
        group.long 0x1834--0x1837 "BAM_P_RETR_CNTXT_0 (at 0xFC9C5834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_0"
        group.long 0x1838--0x183B "BAM_P_SI_CNTXT_0 (at 0xFC9C5838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_0"
        group.long 0x1830--0x1833 "BAM_P_DF_CNTXT_0 (at 0xFC9C5830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_0"
        group.long 0x1804--0x1807 "BAM_P_AU_PSM_CNTXT_1_0 (at 0xFC9C5804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_0"
        group.long 0x1808--0x180B "BAM_P_PSM_CNTXT_2_0 (at 0xFC9C5808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_0"
        group.long 0x180C--0x180F "BAM_P_PSM_CNTXT_3_0 (at 0xFC9C580C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_0"
        group.long 0x1810--0x1813 "BAM_P_PSM_CNTXT_4_0 (at 0xFC9C5810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_0"
        group.long 0x1814--0x1817 "BAM_P_PSM_CNTXT_5_0 (at 0xFC9C5814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 0
tree.end
tree "Pipe 1"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL1"
        group.long 0x2000--0x2003 "BAM_P_CTRL1 (at 0xFC9C6000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST1"
        group.long 0x2004--0x2007 "BAM_P_RST1 (at 0xFC9C6004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT1"
        group.long 0x2008--0x200B "BAM_P_HALT1 (at 0xFC9C6008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG1"
        group.long 0x2030--0x2033 "BAM_P_TRUST_REG1 (at 0xFC9C6030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS1"
        group.long 0x2010--0x2013 "BAM_P_IRQ_STTS1 (at 0xFC9C6010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR1"
        group.long 0x2014--0x2017 "BAM_P_IRQ_CLR1 (at 0xFC9C6014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN1"
        group.long 0x2018--0x201B "BAM_P_IRQ_EN1 (at 0xFC9C6018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER1"
        group.long 0x201C--0x201F "BAM_P_TIMER1 (at 0xFC9C601C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL1"
        group.long 0x2020--0x2023 "BAM_P_TIMER_CTRL1 (at 0xFC9C6020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND1"
        group.long 0x2024--0x2027 "BAM_P_PRDCR_SDBND1 (at 0xFC9C6024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND1"
        group.long 0x2028--0x202B "BAM_P_CNSMR_SDBND1 (at 0xFC9C6028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR1"
        group.long 0x282C--0x282F "BAM_P_EVNT_DEST_ADDR1 (at 0xFC9C682C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG1"
        group.long 0x2818--0x281B "BAM_P_EVNT_REG1 (at 0xFC9C6818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS1"
        group.long 0x2800--0x2803 "BAM_P_SW_OFSTS1 (at 0xFC9C6800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR1"
        group.long 0x2824--0x2827 "BAM_P_DATA_FIFO_ADDR1 (at 0xFC9C6824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR1"
        group.long 0x281C--0x281F "BAM_P_DESC_FIFO_ADDR1 (at 0xFC9C681C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD1"
        group.long 0x2828--0x282B "BAM_P_EVNT_GEN_TRSHLD1 (at 0xFC9C6828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES1"
        group.long 0x2820--0x2823 "BAM_P_FIFO_SIZES1 (at 0xFC9C6820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_1"
        group.long 0x2834--0x2837 "BAM_P_RETR_CNTXT_1 (at 0xFC9C6834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_1"
        group.long 0x2838--0x283B "BAM_P_SI_CNTXT_1 (at 0xFC9C6838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_1"
        group.long 0x2830--0x2833 "BAM_P_DF_CNTXT_1 (at 0xFC9C6830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_1"
        group.long 0x2804--0x2807 "BAM_P_AU_PSM_CNTXT_1_1 (at 0xFC9C6804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_1"
        group.long 0x2808--0x280B "BAM_P_PSM_CNTXT_2_1 (at 0xFC9C6808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_1"
        group.long 0x280C--0x280F "BAM_P_PSM_CNTXT_3_1 (at 0xFC9C680C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_1"
        group.long 0x2810--0x2813 "BAM_P_PSM_CNTXT_4_1 (at 0xFC9C6810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_1"
        group.long 0x2814--0x2817 "BAM_P_PSM_CNTXT_5_1 (at 0xFC9C6814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 1
tree.end
tree.end
;Block Per Data Ends

base ad:0xF9804000
tree "SDC1"
tree "BAM Control Registers"
      tree "BAM_CTRL"
        group.long 0x0--0x3 "BAM_CTRL (at 0xF9804000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x13 " [   19]   CACHE_MISS_ERR_RESP_EN                   = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11--0x12 " [18:17]   LOCAL_CLK_GATING                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   IBC_DISABLE                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0xF " [   15]   BAM_CACHED_DESC_STORE                    = "  "0,1"
        textline ""
        bitfld.long 0x0 0xD--0xE " [14:13]   BAM_DESC_CACHE_SEL                       = "  "0,1,2,3"
        textline ""
        hexmask.long.word 0x0 0x5--0xB 1  " [11:05]   BAM_TESTBUS_SEL                          = " 
        textline ""
        bitfld.long 0x0 0x4 " [   04]   BAM_EN_ACCUM                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_EN                                   = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   BAM_SW_RST                               = "  "0,1"
        textline ""
      tree.end
      tree "BAM_REVISION"
        group.long 0x4--0x7 "BAM_REVISION (at 0xF9804004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x18--0x1F 1  " [31:24]   INACTIV_TMR_BASE                         = " 
        textline ""
        bitfld.long 0x0 0x17 " [   23]   CMD_DESC_EN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15--0x16 " [22:21]   DESC_CACHE_DEPTH                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   NUM_INACTIV_TMRS                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x13 " [   19]   INACTIV_TMRS_EXST                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x12 " [   18]   HIGH_FREQUENCY_BAM                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11 " [   17]   BAM_HAS_NO_BYPASS                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   SECURED                                  = "  "0,1"
        textline ""
        bitfld.long 0x0 0xF " [   15]   USE_VMIDMT                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0xE " [   14]   AXI_ACTIVE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0xD " [   13]   CE_BUFFER_SIZE                           = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x8--0xB 1  " [11:08]   NUM_EES                                  = " 
        textline ""
        hexmask.long.word 0x0 0x0--0x7 1  " [07:00]   REVISION                                 = " 
        textline ""
      tree.end
      tree "BAM_SW_VERSION"
        group.long 0x80--0x83 "BAM_SW_VERSION (at 0xF9804080) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x1C--0x1F 1  " [31:28]   MAJOR                                    = " 
        textline ""
        hexmask.long.word 0x0 0x10--0x1B 1  " [27:16]   MINOR                                    = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   STEP                                     = " 
        textline ""
      tree.end
      tree "BAM_NUM_PIPES"
        group.long 0x3C--0x3F "BAM_NUM_PIPES (at 0xF980403C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x18--0x1F 1  " [31:24]   BAM_NON_PIPE_GRP                         = " 
        textline ""
        hexmask.long.word 0x0 0x10--0x17 1  " [23:16]   PERIPH_NON_PIPE_GRP                      = " 
        textline ""
        hexmask.long.word 0x0 0x0--0x7 1  " [07:00]   BAM_NUM_PIPES                            = " 
        textline ""
      tree.end
      tree "BAM_TIMER"
        group.long 0x40--0x43 "BAM_TIMER (at 0xF9804040) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   TIMER                                    = " 
        textline ""
      tree.end
      tree "BAM_TIMER_CTRL"
        group.long 0x44--0x47 "BAM_TIMER_CTRL (at 0xF9804044) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   TIMER_RST                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   TIMER_RUN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   TIMER_MODE                               = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   TIMER_TRSHLD                             = " 
        textline ""
      tree.end
      tree "BAM_DESC_CNT_TRSHLD"
        group.long 0x8--0xB "BAM_DESC_CNT_TRSHLD (at 0xF9804008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   CNT_TRSHLD                               = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS"
        group.long 0xC--0xF "BAM_IRQ_SRCS (at 0xF980400C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK"
        group.long 0x10--0x13 "BAM_IRQ_SRCS_MSK (at 0xF9804010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED"
        group.long 0x30--0x33 "BAM_IRQ_SRCS_UNMASKED (at 0xF9804030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_STTS"
        group.long 0x14--0x17 "BAM_IRQ_STTS (at 0xF9804014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x4 " [   04]   BAM_TIMER_IRQ                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   BAM_EMPTY_IRQ                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_ERROR_IRQ                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_HRESP_ERR_IRQ                        = "  "0,1"
        textline ""
      tree.end
      tree "BAM_IRQ_CLR"
        group.long 0x18--0x1B "BAM_IRQ_CLR (at 0xF9804018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x4 " [   04]   BAM_TIMER_CLR                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   BAM_EMPTY_CLR                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_ERROR_CLR                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_HRESP_ERR_CLR                        = "  "0,1"
        textline ""
      tree.end
      tree "BAM_IRQ_EN"
        group.long 0x1C--0x1F "BAM_IRQ_EN (at 0xF980401C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x4 " [   04]   BAM_TIMER_EN                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   BAM_EMPTY_EN                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_ERROR_EN                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_HRESP_ERR_EN                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_AHB_MASTER_ERR_CTRLS"
        group.long 0x24--0x27 "BAM_AHB_MASTER_ERR_CTRLS (at 0xF9804024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x12--0x16 1  " [22:18]   BAM_ERR_HVMID                            = " 
        textline ""
        bitfld.long 0x0 0x11 " [   17]   BAM_ERR_DIRECT_MODE                      = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0xC--0x10 1  " [16:12]   BAM_ERR_HCID                             = " 
        textline ""
        hexmask.long.word 0x0 0x8--0xB 1  " [11:08]   BAM_ERR_HPROT                            = " 
        textline ""
        bitfld.long 0x0 0x5--0x7 " [07:05]   BAM_ERR_HBURST                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x3--0x4 " [04:03]   BAM_ERR_HSIZE                            = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_ERR_HWRITE                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0--0x1 " [01:00]   BAM_ERR_HTRANS                           = "  "0,1,2,3"
        textline ""
      tree.end
      tree "BAM_AHB_MASTER_ERR_ADDR"
        group.long 0x28--0x2B "BAM_AHB_MASTER_ERR_ADDR (at 0xF9804028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   BAM_ERR_ADDR                             = " 
        textline ""
      tree.end
      tree "BAM_AHB_MASTER_ERR_DATA"
        group.long 0x2C--0x2F "BAM_AHB_MASTER_ERR_DATA (at 0xF980402C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   BAM_ERR_DATA                             = " 
        textline ""
      tree.end
      tree "BAM_TRUST_REG"
        group.long 0x70--0x73 "BAM_TRUST_REG (at 0xF9804070) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0xD " [   13]   LOCK_EE_CTRL                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_VMID                                 = " 
        textline ""
        bitfld.long 0x0 0x7 " [   07]   BAM_RST_BLOCK                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_EE                                   = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_TEST_BUS_SEL"
        group.long 0x74--0x77 "BAM_TEST_BUS_SEL (at 0xF9804074) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x15 " [   21]   SW_EVENTS_ZERO                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x13--0x14 " [20:19]   SW_EVENTS_SEL                            = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x12 " [   18]   BAM_DATA_ERASE                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11 " [   17]   BAM_DATA_FLUSH                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   BAM_CLK_ALWAYS_ON                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x0--0x6 1  " [06:00]   BAM_TESTBUS_SEL                          = " 
        textline ""
      tree.end
      tree "BAM_TEST_BUS_REG"
        group.long 0x78--0x7B "BAM_TEST_BUS_REG (at 0xF9804078) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   BAM_TESTBUS_REG                          = " 
        textline ""
      tree.end
      tree "BAM_CNFG_BITS"
        group.long 0x7C--0x7F "BAM_CNFG_BITS (at 0xF980407C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1C " [   28]   BAM_ZLT_W_CD_SUPPORT                     = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1B " [   27]   BAM_CD_ENABLE                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1A " [   26]   BAM_AU_ACCUMED                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x19 " [   25]   BAM_PSM_P_HD_DATA                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_REG_P_EN                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_WB_DSC_AVL_P_RST                     = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_WB_RETR_SVPNT                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_WB_CSW_ACK_IDL                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_WB_BLK_CSW                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x13 " [   19]   BAM_WB_P_RES                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x12 " [   18]   BAM_SI_P_RES                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x11 " [   17]   BAM_AU_P_RES                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x10 " [   16]   BAM_PSM_P_RES                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0xF " [   15]   BAM_PSM_CSW_REQ                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0xE " [   14]   BAM_SB_CLK_REQ                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0xD " [   13]   BAM_IBC_DISABLE                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0xC " [   12]   BAM_NO_EXT_P_RST                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0xB " [   11]   BAM_FULL_PIPE                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   BAM_ADML_SYNC_BRIDGE                     = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   BAM_PIPE_CNFG                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   BAM_ADML_DEEP_CONS_FIFO                  = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   BAM_ADML_INCR4_EN_N                      = "  "0,1"
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE0"
        group.long 0x800--0x803 "BAM_IRQ_SRCS_EE0 (at 0xF9804800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE1"
        group.long 0x880--0x883 "BAM_IRQ_SRCS_EE1 (at 0xF9804880) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE2"
        group.long 0x900--0x903 "BAM_IRQ_SRCS_EE2 (at 0xF9804900) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE3"
        group.long 0x980--0x983 "BAM_IRQ_SRCS_EE3 (at 0xF9804980) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE4"
        group.long 0xA00--0xA03 "BAM_IRQ_SRCS_EE4 (at 0xF9804A00) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE5"
        group.long 0xA80--0xA83 "BAM_IRQ_SRCS_EE5 (at 0xF9804A80) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE6"
        group.long 0xB00--0xB03 "BAM_IRQ_SRCS_EE6 (at 0xF9804B00) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_EE7"
        group.long 0xB80--0xB83 "BAM_IRQ_SRCS_EE7 (at 0xF9804B80) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ                                  = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ                                    = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE0"
        group.long 0x804--0x807 "BAM_IRQ_SRCS_MSK_EE0 (at 0xF9804804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE1"
        group.long 0x884--0x887 "BAM_IRQ_SRCS_MSK_EE1 (at 0xF9804884) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE2"
        group.long 0x904--0x907 "BAM_IRQ_SRCS_MSK_EE2 (at 0xF9804904) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE3"
        group.long 0x984--0x987 "BAM_IRQ_SRCS_MSK_EE3 (at 0xF9804984) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE4"
        group.long 0xA04--0xA07 "BAM_IRQ_SRCS_MSK_EE4 (at 0xF9804A04) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE5"
        group.long 0xA84--0xA87 "BAM_IRQ_SRCS_MSK_EE5 (at 0xF9804A84) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE6"
        group.long 0xB04--0xB07 "BAM_IRQ_SRCS_MSK_EE6 (at 0xF9804B04) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_MSK_EE7"
        group.long 0xB84--0xB87 "BAM_IRQ_SRCS_MSK_EE7 (at 0xF9804B84) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_MSK                              = "  "0 (DISABLE_BAM_INTERRUPT),1 (ENABLE_BAM_INTERRUPT)"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_MSK                                = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE0"
        group.long 0x808--0x80B "BAM_IRQ_SRCS_UNMASKED_EE0 (at 0xF9804808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE1"
        group.long 0x888--0x88B "BAM_IRQ_SRCS_UNMASKED_EE1 (at 0xF9804888) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE2"
        group.long 0x908--0x90B "BAM_IRQ_SRCS_UNMASKED_EE2 (at 0xF9804908) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE3"
        group.long 0x988--0x98B "BAM_IRQ_SRCS_UNMASKED_EE3 (at 0xF9804988) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE4"
        group.long 0xA08--0xA0B "BAM_IRQ_SRCS_UNMASKED_EE4 (at 0xF9804A08) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE5"
        group.long 0xA88--0xA8B "BAM_IRQ_SRCS_UNMASKED_EE5 (at 0xF9804A88) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE6"
        group.long 0xB08--0xB0B "BAM_IRQ_SRCS_UNMASKED_EE6 (at 0xF9804B08) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
      tree "BAM_IRQ_SRCS_UNMASKED_EE7"
        group.long 0xB88--0xB8B "BAM_IRQ_SRCS_UNMASKED_EE7 (at 0xF9804B88) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   BAM_IRQ_UNMASKED                         = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0x1E 1  " [30:00]   P_IRQ_UNMASKED                           = " 
        textline ""
      tree.end
;End of BAM Control Registers
tree.end
tree "Pipe 0"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL0"
        group.long 0x1000--0x1003 "BAM_P_CTRL0 (at 0xF9805000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST0"
        group.long 0x1004--0x1007 "BAM_P_RST0 (at 0xF9805004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT0"
        group.long 0x1008--0x100B "BAM_P_HALT0 (at 0xF9805008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG0"
        group.long 0x1030--0x1033 "BAM_P_TRUST_REG0 (at 0xF9805030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS0"
        group.long 0x1010--0x1013 "BAM_P_IRQ_STTS0 (at 0xF9805010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR0"
        group.long 0x1014--0x1017 "BAM_P_IRQ_CLR0 (at 0xF9805014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN0"
        group.long 0x1018--0x101B "BAM_P_IRQ_EN0 (at 0xF9805018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER0"
        group.long 0x101C--0x101F "BAM_P_TIMER0 (at 0xF980501C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL0"
        group.long 0x1020--0x1023 "BAM_P_TIMER_CTRL0 (at 0xF9805020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND0"
        group.long 0x1024--0x1027 "BAM_P_PRDCR_SDBND0 (at 0xF9805024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND0"
        group.long 0x1028--0x102B "BAM_P_CNSMR_SDBND0 (at 0xF9805028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR0"
        group.long 0x182C--0x182F "BAM_P_EVNT_DEST_ADDR0 (at 0xF980582C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG0"
        group.long 0x1818--0x181B "BAM_P_EVNT_REG0 (at 0xF9805818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS0"
        group.long 0x1800--0x1803 "BAM_P_SW_OFSTS0 (at 0xF9805800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR0"
        group.long 0x1824--0x1827 "BAM_P_DATA_FIFO_ADDR0 (at 0xF9805824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR0"
        group.long 0x181C--0x181F "BAM_P_DESC_FIFO_ADDR0 (at 0xF980581C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD0"
        group.long 0x1828--0x182B "BAM_P_EVNT_GEN_TRSHLD0 (at 0xF9805828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES0"
        group.long 0x1820--0x1823 "BAM_P_FIFO_SIZES0 (at 0xF9805820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_0"
        group.long 0x1834--0x1837 "BAM_P_RETR_CNTXT_0 (at 0xF9805834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_0"
        group.long 0x1838--0x183B "BAM_P_SI_CNTXT_0 (at 0xF9805838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_0"
        group.long 0x1830--0x1833 "BAM_P_DF_CNTXT_0 (at 0xF9805830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_0"
        group.long 0x1804--0x1807 "BAM_P_AU_PSM_CNTXT_1_0 (at 0xF9805804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_0"
        group.long 0x1808--0x180B "BAM_P_PSM_CNTXT_2_0 (at 0xF9805808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_0"
        group.long 0x180C--0x180F "BAM_P_PSM_CNTXT_3_0 (at 0xF980580C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_0"
        group.long 0x1810--0x1813 "BAM_P_PSM_CNTXT_4_0 (at 0xF9805810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_0"
        group.long 0x1814--0x1817 "BAM_P_PSM_CNTXT_5_0 (at 0xF9805814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 0
tree.end
tree "Pipe 1"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL1"
        group.long 0x2000--0x2003 "BAM_P_CTRL1 (at 0xF9806000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST1"
        group.long 0x2004--0x2007 "BAM_P_RST1 (at 0xF9806004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT1"
        group.long 0x2008--0x200B "BAM_P_HALT1 (at 0xF9806008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG1"
        group.long 0x2030--0x2033 "BAM_P_TRUST_REG1 (at 0xF9806030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS1"
        group.long 0x2010--0x2013 "BAM_P_IRQ_STTS1 (at 0xF9806010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR1"
        group.long 0x2014--0x2017 "BAM_P_IRQ_CLR1 (at 0xF9806014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN1"
        group.long 0x2018--0x201B "BAM_P_IRQ_EN1 (at 0xF9806018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER1"
        group.long 0x201C--0x201F "BAM_P_TIMER1 (at 0xF980601C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL1"
        group.long 0x2020--0x2023 "BAM_P_TIMER_CTRL1 (at 0xF9806020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND1"
        group.long 0x2024--0x2027 "BAM_P_PRDCR_SDBND1 (at 0xF9806024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND1"
        group.long 0x2028--0x202B "BAM_P_CNSMR_SDBND1 (at 0xF9806028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR1"
        group.long 0x282C--0x282F "BAM_P_EVNT_DEST_ADDR1 (at 0xF980682C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG1"
        group.long 0x2818--0x281B "BAM_P_EVNT_REG1 (at 0xF9806818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS1"
        group.long 0x2800--0x2803 "BAM_P_SW_OFSTS1 (at 0xF9806800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR1"
        group.long 0x2824--0x2827 "BAM_P_DATA_FIFO_ADDR1 (at 0xF9806824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR1"
        group.long 0x281C--0x281F "BAM_P_DESC_FIFO_ADDR1 (at 0xF980681C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD1"
        group.long 0x2828--0x282B "BAM_P_EVNT_GEN_TRSHLD1 (at 0xF9806828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES1"
        group.long 0x2820--0x2823 "BAM_P_FIFO_SIZES1 (at 0xF9806820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_1"
        group.long 0x2834--0x2837 "BAM_P_RETR_CNTXT_1 (at 0xF9806834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_1"
        group.long 0x2838--0x283B "BAM_P_SI_CNTXT_1 (at 0xF9806838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_1"
        group.long 0x2830--0x2833 "BAM_P_DF_CNTXT_1 (at 0xF9806830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_1"
        group.long 0x2804--0x2807 "BAM_P_AU_PSM_CNTXT_1_1 (at 0xF9806804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_1"
        group.long 0x2808--0x280B "BAM_P_PSM_CNTXT_2_1 (at 0xF9806808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_1"
        group.long 0x280C--0x280F "BAM_P_PSM_CNTXT_3_1 (at 0xF980680C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_1"
        group.long 0x2810--0x2813 "BAM_P_PSM_CNTXT_4_1 (at 0xF9806810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_1"
        group.long 0x2814--0x2817 "BAM_P_PSM_CNTXT_5_1 (at 0xF9806814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 1
tree.end
tree "Pipe 2"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL2"
        group.long 0x3000--0x3003 "BAM_P_CTRL2 (at 0xF9807000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST2"
        group.long 0x3004--0x3007 "BAM_P_RST2 (at 0xF9807004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT2"
        group.long 0x3008--0x300B "BAM_P_HALT2 (at 0xF9807008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG2"
        group.long 0x3030--0x3033 "BAM_P_TRUST_REG2 (at 0xF9807030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS2"
        group.long 0x3010--0x3013 "BAM_P_IRQ_STTS2 (at 0xF9807010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR2"
        group.long 0x3014--0x3017 "BAM_P_IRQ_CLR2 (at 0xF9807014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN2"
        group.long 0x3018--0x301B "BAM_P_IRQ_EN2 (at 0xF9807018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER2"
        group.long 0x301C--0x301F "BAM_P_TIMER2 (at 0xF980701C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL2"
        group.long 0x3020--0x3023 "BAM_P_TIMER_CTRL2 (at 0xF9807020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND2"
        group.long 0x3024--0x3027 "BAM_P_PRDCR_SDBND2 (at 0xF9807024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND2"
        group.long 0x3028--0x302B "BAM_P_CNSMR_SDBND2 (at 0xF9807028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR2"
        group.long 0x382C--0x382F "BAM_P_EVNT_DEST_ADDR2 (at 0xF980782C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG2"
        group.long 0x3818--0x381B "BAM_P_EVNT_REG2 (at 0xF9807818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS2"
        group.long 0x3800--0x3803 "BAM_P_SW_OFSTS2 (at 0xF9807800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR2"
        group.long 0x3824--0x3827 "BAM_P_DATA_FIFO_ADDR2 (at 0xF9807824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR2"
        group.long 0x381C--0x381F "BAM_P_DESC_FIFO_ADDR2 (at 0xF980781C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD2"
        group.long 0x3828--0x382B "BAM_P_EVNT_GEN_TRSHLD2 (at 0xF9807828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES2"
        group.long 0x3820--0x3823 "BAM_P_FIFO_SIZES2 (at 0xF9807820) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_DATA_FIFO_SIZE                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_SIZE                         = " 
        textline ""
      tree.end
;End of Pipe Config Registers
tree.end
tree "Pipe Internal State Registers"
      tree "BAM_P_RETR_CNTXT_2"
        group.long 0x3834--0x3837 "BAM_P_RETR_CNTXT_2 (at 0xF9807834) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   RETR_DESC_OFST                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   RETR_OFST_IN_DESC                        = " 
        textline ""
      tree.end
      tree "BAM_P_SI_CNTXT_2"
        group.long 0x3838--0x383B "BAM_P_SI_CNTXT_2 (at 0xF9807838) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SI_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DF_CNTXT_2"
        group.long 0x3830--0x3833 "BAM_P_DF_CNTXT_2 (at 0xF9807830) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   WB_ACCUMULATED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   DF_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_AU_PSM_CNTXT_1_2"
        group.long 0x3804--0x3807 "BAM_P_AU_PSM_CNTXT_1_2 (at 0xF9807804) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   AU_PSM_ACCUMED                           = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   AU_ACKED                                 = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_2_2"
        group.long 0x3808--0x380B "BAM_P_PSM_CNTXT_2_2 (at 0xF9807808) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   PSM_DESC_VALID                           = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   PSM_DESC_IRQ                             = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   PSM_DESC_IRQ_DONE                        = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x19--0x1C 1  " [28:25]   PSM_GENERAL_BITS                         = " 
        textline ""
        bitfld.long 0x0 0x16--0x18 " [24:22]   PSM_CONS_STATE                           = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x13--0x15 " [21:19]   PSM_PROD_SYS_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        bitfld.long 0x0 0x10--0x12 " [18:16]   PSM_PROD_B2B_STATE                       = "  "0,1,2,3,4,5,6,7"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_DESC_SIZE                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_3_2"
        group.long 0x380C--0x380F "BAM_P_PSM_CNTXT_3_2 (at 0xF980780C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   PSM_DESC_ADDR                            = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_4_2"
        group.long 0x3810--0x3813 "BAM_P_PSM_CNTXT_4_2 (at 0xF9807810) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_DESC_OFST                            = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_SAVED_ACCUMED_SIZE                   = " 
        textline ""
      tree.end
      tree "BAM_P_PSM_CNTXT_5_2"
        group.long 0x3814--0x3817 "BAM_P_PSM_CNTXT_5_2 (at 0xF9807814) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   PSM_BLOCK_BYTE_CNT                       = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   PSM_OFST_IN_DESC                         = " 
        textline ""
      tree.end
;End of Pipe Internal State Registers
tree.end
;End of Pipe 2
tree.end
tree "Pipe 3"
tree "Pipe Management Registers"
      tree "BAM_P_CTRL3"
        group.long 0x4000--0x4003 "BAM_P_CTRL3 (at 0xF9808000) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x10--0x14 1  " [20:16]   P_LOCK_GROUP                             = " 
        textline ""
        bitfld.long 0x0 0xB " [   11]   P_WRITE_NWD                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x9--0xA " [10:09]   P_PREFETCH_LIMIT                         = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x7--0x8 " [08:07]   P_AUTO_EOB_SEL                           = "  "0,1,2,3"
        textline ""
        bitfld.long 0x0 0x6 " [   06]   P_AUTO_EOB                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_SYS_MODE                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_SYS_STRM                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_DIRECTION                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_EN                                     = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_RST3"
        group.long 0x4004--0x4007 "BAM_P_RST3 (at 0xF9808004) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_SW_RST                                 = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_HALT3"
        group.long 0x4008--0x400B "BAM_P_HALT3 (at 0xF9808008) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_PROD_HALTED                            = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_HALT                                   = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TRUST_REG3"
        group.long 0x4030--0x4033 "BAM_P_TRUST_REG3 (at 0xF9808030) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.word 0x0 0x8--0xC 1  " [12:08]   BAM_P_VMID                               = " 
        textline ""
        bitfld.long 0x0 0x0--0x2 " [02:00]   BAM_P_EE                                 = "  "0,1,2,3,4,5,6,7"
        textline ""
      tree.end
      tree "BAM_P_IRQ_STTS3"
        group.long 0x4010--0x4013 "BAM_P_IRQ_STTS3 (at 0xF9808010) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_IRQ                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_IRQ                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_IRQ                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_IRQ                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_IRQ                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_IRQ                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_CLR3"
        group.long 0x4014--0x4017 "BAM_P_IRQ_CLR3 (at 0xF9808014) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_CLR                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_CLR                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_CLR                        = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_CLR                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_CLR                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_CLR                         = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_IRQ_EN3"
        group.long 0x4018--0x401B "BAM_P_IRQ_EN3 (at 0xF9808018) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x5 " [   05]   P_TRNSFR_END_EN                          = "  "0,1"
        textline ""
        bitfld.long 0x0 0x4 " [   04]   P_ERR_EN                                 = "  "0,1"
        textline ""
        bitfld.long 0x0 0x3 " [   03]   P_OUT_OF_DESC_EN                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x2 " [   02]   P_WAKE_EN                                = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1 " [   01]   P_TIMER_EN                               = "  "0,1"
        textline ""
        bitfld.long 0x0 0x0 " [   00]   P_PRCSD_DESC_EN                          = "  "0,1"
        textline ""
      tree.end
      tree "BAM_P_TIMER3"
        group.long 0x401C--0x401F "BAM_P_TIMER3 (at 0xF980801C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER                                  = " 
        textline ""
      tree.end
      tree "BAM_P_TIMER_CTRL3"
        group.long 0x4020--0x4023 "BAM_P_TIMER_CTRL3 (at 0xF9808020) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x1F " [   31]   P_TIMER_RST                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1E " [   30]   P_TIMER_RUN                              = "  "0,1"
        textline ""
        bitfld.long 0x0 0x1D " [   29]   P_TIMER_MODE                             = "  "0,1"
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TIMER_TRSHLD                           = " 
        textline ""
      tree.end
      tree "BAM_P_PRDCR_SDBND3"
        group.long 0x4024--0x4027 "BAM_P_PRDCR_SDBND3 (at 0xF9808024) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_FREE                         = " 
        textline ""
      tree.end
      tree "BAM_P_CNSMR_SDBND3"
        group.long 0x4028--0x402B "BAM_P_CNSMR_SDBND3 (at 0xF9808028) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        bitfld.long 0x0 0x18 " [   24]   BAM_P_SB_UPDATED                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x17 " [   23]   BAM_P_WAIT_4_ACK                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x16 " [   22]   BAM_P_ACK_TOGGLE                         = "  "0,1"
        textline ""
        bitfld.long 0x0 0x15 " [   21]   BAM_P_ACK_TOGGLE_R                       = "  "0,1"
        textline ""
        bitfld.long 0x0 0x14 " [   20]   BAM_P_TOGGLE                             = "  "0,1"
        textline ""
        hexmask.long.word 0x0 0x10--0x13 1  " [19:16]   BAM_P_CTRL                               = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   BAM_P_BYTES_AVAIL                        = " 
        textline ""
      tree.end
;End of Pipe Management Registers
tree.end
tree "Pipe Config Registers"
      tree "BAM_P_EVNT_DEST_ADDR3"
        group.long 0x482C--0x482F "BAM_P_EVNT_DEST_ADDR3 (at 0xF980882C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_EVNT_DEST_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_REG3"
        group.long 0x4818--0x481B "BAM_P_EVNT_REG3 (at 0xF9808818) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   P_BYTES_CONSUMED                         = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_DESC_FIFO_PEER_OFST                    = " 
        textline ""
      tree.end
      tree "BAM_P_SW_OFSTS3"
        group.long 0x4800--0x4803 "BAM_P_SW_OFSTS3 (at 0xF9808800) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x10--0x1F 1  " [31:16]   SW_OFST_IN_DESC                          = " 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   SW_DESC_OFST                             = " 
        textline ""
      tree.end
      tree "BAM_P_DATA_FIFO_ADDR3"
        group.long 0x4824--0x4827 "BAM_P_DATA_FIFO_ADDR3 (at 0xF9808824) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DATA_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_DESC_FIFO_ADDR3"
        group.long 0x481C--0x481F "BAM_P_DESC_FIFO_ADDR3 (at 0xF980881C) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0x1F 1  " [31:00]   P_DESC_FIFO_ADDR                         = " 
        textline ""
      tree.end
      tree "BAM_P_EVNT_GEN_TRSHLD3"
        group.long 0x4828--0x482B "BAM_P_EVNT_GEN_TRSHLD3 (at 0xF9808828) "
        line.long 0x0 "VALUE"
        textline "BITS" 
        textline ""
        hexmask.long.long 0x0 0x0--0xF 1  " [15:00]   P_TRSHLD                                 = " 
        textline ""
      tree.end
      tree "BAM_P_FIFO_SIZES3"
        group.long 0x4820--0x4823 "BAM_P_FIFO_SIZES3 (at 0xF9808820) "
        line.long 0x0 "VALUE"
